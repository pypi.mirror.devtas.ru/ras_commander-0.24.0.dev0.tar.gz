HEC-RAS study BaldEagle.prj: Bald Eagle Cr. for the WCDS Project

--- BaldEagle.f01 (steady flow) ---

Flow Title=Debug Mode - PostProcess Steady Flow
Version=Version 3.0 Beta
Number of Profiles= 76
Profile Names=Max WS,17Feb1999 2400,18Feb1999 0200,18Feb1999 0400,18Feb1999 0600,18Feb1999 0800,18Feb1999 1000,18Feb1999 1200,18Feb1999 1400,18Feb1999 1600,18Feb1999 1800,18Feb1999 2000,18Feb1999 2200,18Feb1999 2400,19Feb1999 0200,19Feb1999 0400,19Feb1999 0600,19Feb1999 0800,19Feb1999 1000,19Feb1999 1200,19Feb1999 1400,19Feb1999 1600,19Feb1999 1800,19Feb1999 2000,19Feb1999 2200,19Feb1999 2400,20Feb1999 0200,20Feb1999 0400,20Feb1999 0600,20Feb1999 0800,20Feb1999 1000,20Feb1999 1200,20Feb1999 1400,20Feb1999 1600,20Feb1999 1800,20Feb1999 2000,20Feb1999 2200,20Feb1999 2400,21Feb1999 0200,21Feb1999 0400,21Feb1999 0600,21Feb1999 0800,21Feb1999 1000,21Feb1999 1200,21Feb1999 1400,21Feb1999 1600,21Feb1999 1800,21Feb1999 2000,21Feb1999 2200,21Feb1999 2400,22Feb1999 0200,22Feb1999 0400,22Feb1999 0600,22Feb1999 0800,22Feb1999 1000,22Feb1999 1200,22Feb1999 1400,22Feb1999 1600,22Feb1999 1800,22Feb1999 2000,22Feb1999 2200,22Feb1999 2400,23Feb1999 0200,23Feb1999 0400,23Feb1999 0600,23Feb1999 0800,23Feb1999 1000,23Feb1999 1200,23Feb1999 1400,23Feb1999 1600,23Feb1999 1800,23Feb1999 2000,23Feb1999 2200,23Feb1999 2400,24Feb1999 0200,24Feb1999 0400
River Rch & RM=Bald Eagle,Loc Hav         ,138154.4
49985.15    1000 3512.82 6025.64 8538.4611051.28 13564.116076.9218589.7421102.56
23615.3826128.2128641.0331153.8533666.6736179.4938692.3141205.1343717.9546230.77
48743.5949554.5548663.6447772.7346881.8245990.91   4510044209.0943318.1842427.27
41536.3640645.4539754.5538863.6437972.7337081.8236190.91   3530034409.0933518.18
32627.2731736.3630845.4629954.5429063.6428172.7327281.8226390.91   2550024609.09
23718.1822827.2721936.3621045.4620154.5419263.6418372.7317481.8216590.91   15700
14809.0913918.1813027.2712136.3611245.4510354.55 9463.64 8572.73 7681.82 6790.91
    5900 5009.09 4118.18 3227.27 2336.36 1445.46
River Rch & RM=Bald Eagle,Loc Hav         ,137690.8
49982.39999.9879  3467.85980.094  8507.411021.1313541.1516054.2518567.96 21082.2
23597.48 26110.628624.2631137.2433650.3636164.5938677.7541190.9943703.93   46217
48731.4849558.8448667.95   4777746886.59 45995.545104.5844213.5543322.5642431.79
 41540.940650.1839759.48 38868.737977.9937087.15 36196.335305.4334414.5733523.74
32632.9131742.0230851.1829960.29 29069.828178.9427288.0826397.4525506.5224615.74
23724.88   2283421943.1421052.3320161.4219271.2418380.3317490.0416599.2315708.42
14817.5913926.8113035.9612145.1711255.1410365.759475.0268584.3557693.6646802.903
5913.7545025.9744135.511 3244.712356.6761468.567
River Rch & RM=Bald Eagle,Loc Hav         ,137327.0
49978.73999.98433424.6745937.2228477.134 10991.813517.6916031.1118545.4621060.72
23578.8926092.3228606.7931120.0433633.46 36149.338662.69 41176.443689.4946202.79
48719.0349563.2148672.3947781.4146891.5446000.2845109.21 44218.143327.0442436.41
41545.5940655.0739764.53 38873.937983.3937092.6236201.8335311.0234420.2333529.47
 32638.731747.8630857.0829966.2129076.2428185.4827294.6426404.2225513.3524622.66
23731.8422840.9821950.1821059.4920168.6419279.2418388.4517498.5216607.8415717.09
 14826.413935.6913044.9512154.2711264.5910376.719486.1848595.8237705.4166814.828
5926.1135041.9814152.191  3261.92372.1461486.455
River Rch & RM=Bald Eagle,Loc Hav         ,136564.9
49960.71999.97593354.6355877.4948428.80110947.1713478.4815993.8618509.4221025.94
23546.8326061.8828577.1631091.2133605.2836121.8938636.4141150.6343664.0746177.95
48694.8749571.7848680.8847789.8646899.58 46007.545115.5344223.89 43332.942442.56
41552.2940662.4839772.5638882.54 37992.337101.8836211.3835320.7334430.0733539.58
32648.8631758.3630867.7529976.9629087.0728196.6527305.7726415.56 25524.924634.15
23743.48 22852.721962.24 21071.920181.1119292.3718401.8817512.2716621.75 15731.2
14840.7313950.0913059.8812169.5211279.26 10393.39503.1968613.5597723.5176833.403
5945.1515064.2114175.5063286.3962392.8991510.349
River Rch & RM=Bald Eagle,Loc Hav         ,136202.3
49959.59999.96913323.6675853.2928406.945 10928.113460.5715978.0218494.2621011.96
 23532.7   2604928564.4731079.1433593.6636109.8638625.1841139.3943653.1946167.54
48683.8649575.6148684.6947793.5646902.5846009.5245116.7644224.6443333.7142443.66
41553.7940664.6839775.3838885.8237995.8237105.62 36215.435324.8134434.2133543.89
32653.2431762.8730872.4329981.6729091.6128201.3627310.5526420.3525529.6924639.01
23748.3622857.6421967.4521077.2520186.5219297.72 18407.317518.06 16627.615737.15
14846.77 13956.213066.2612176.1611285.8910400.199510.2428621.1357731.2286841.318
5953.6885072.6974184.3213295.601 2402.681519.105
River Rch & RM=Bald Eagle,Loc Hav         ,135591.4
49939.57999.96693264.5775810.3738366.20910892.3413428.1115948.7918466.0420987.07
   2350826026.0128542.0331058.2833573.8936090.3238606.5641120.84 43635.446150.87
 48667.349581.3448690.4147798.8646906.7946011.2745116.6844223.5643332.8642443.57
41554.67 40667.339779.2838890.6938001.2737111.6136221.7635331.4634440.9433550.97
32660.51 31770.230880.1429989.3929099.5628209.5227318.8326428.7325537.9824647.46
23756.8222866.2821976.6421086.5820196.0919307.4318417.0617528.5416638.2715748.05
14857.7913967.4213077.5912188.2211298.1510412.859523.1838634.9137745.3816855.883
5968.7825088.8174200.9133312.6632419.0321532.612
River Rch & RM=Bald Eagle,Loc Hav         ,135068.7
41155.91999.9478 3196.795771.4458325.90210859.3513394.85 15917.918436.1520959.58
23480.6825999.9428516.7631035.7933551.0536067.85 38584.841099.32   4361546131.09
48647.7249588.0948696.8847804.5646910.3746010.0545112.2744217.5543327.6342439.82
41552.8940668.5239782.5538895.4738006.9537118.1636228.9135339.08 34448.633558.86
32668.7431778.5530889.2329998.5129108.6728218.98 27328.226438.2925547.54 24657.1
23766.75 22876.221986.6221096.8320206.5419318.05 18427.817539.9616649.9815759.99
14869.8613979.7613089.9912200.5311310.6610425.629536.3258648.5857759.4036870.284
5983.422 5103.164215.5753327.5492432.8451545.967
River Rch & RM=Bald Eagle,Loc Hav         ,134487.2
40447.95999.92163118.574 5710.298273.19410811.3413344.8415873.5118393.5720917.62
23439.7825961.2628479.8131001.5133515.9836033.6938551.95 41066.943584.1346100.45
48617.74 49598.248706.5147812.6846914.2546004.6145101.23   4420443315.9242431.39
41548.1640668.6639786.3138901.7138014.9337127.3536239.2135350.0734459.7833570.18
32680.7131790.7330902.6330011.7629122.1128232.7727341.9826452.17 25561.6 24671.3
23781.0922890.7522001.1921111.8720221.92 19333.518443.7817556.1516666.5415776.74
14887.1313997.2713107.6812217.8211328.3310443.619554.7988666.988 7778.156889.374
6002.8585122.0174234.6813346.8562452.2611564.985
River Rch & RM=Bald Eagle,Loc Hav         ,133881.0
40125.14999.89783064.6465628.0528214.03710750.74 13286.615824.46 18347.520871.91
23396.2925920.5328441.8430964.7933479.7335998.8438518.6541034.2343552.6846069.35
48587.7249608.1148715.9547819.9946915.7845993.8645083.6644184.1343298.9242418.82
41540.1440666.5539788.3838906.6338021.96 37135.836248.7435360.5334470.5233580.96
32692.1831802.5530915.7230024.6229135.2728246.0327355.6226465.7225575.3424685.09
23794.96   2290522015.9821127.0920237.6119349.4618460.0617572.2516683.1515793.65
14904.4714014.72 13125.412235.8811346.5410462.229573.685 8685.597797.034 6908.65
6022.4385141.9424254.8133367.1612472.3921584.994
River Rch & RM=Bald Eagle,Loc Hav         ,133446.1
39832.97  999.872998.2415563.5348170.77210707.5313245.5515790.8118316.6720841.87
23367.5225893.5528417.1630941.3833456.7335976.5738497.3241013.51 43532.646049.62
48568.72 49614.3 48721.8 47824.146915.3645983.8145068.5444167.8543285.2242408.34
41533.23   40664 39788.938909.2338025.85   3714136254.6535366.9934477.2233587.62
32699.2731810.0330924.0530032.8929143.5228254.4427364.0526474.1725583.7324693.56
23803.6522913.9122025.16 21136.720247.4819359.6218470.22 17582.516693.75 15804.5
14915.3714025.8213136.6412247.3811358.11   104749585.536 8697.747809.3076921.096
6035.0925154.7374267.7793380.223 2485.431597.999
River Rch & RM=Bald Eagle,Loc Hav         ,132973.6
39479.42999.84612901.2935497.7148124.84710662.3713201.6415754.2518284.2920810.33
23336.7225864.33 28391.230917.1333432.89 35953.238474.4240991.6243511.38 46028.8
48548.7249620.6348727.6247827.3946912.6645968.6145047.3444145.5343266.6942394.25
41523.8440659.77 39788.638911.3938029.5937146.2236260.7735373.6434484.1633594.57
32706.7931817.9330933.0330041.8229152.4328263.3627372.7326483.0525592.4824702.43
23812.6322923.2822034.8121146.7220257.8219370.1618480.8817593.4116704.8215815.62
14926.7414037.3613148.2812259.16 11370.3 10486.39597.9738710.4647822.1246934.061
6048.1185167.7614281.1423393.704 2499.171611.846
River Rch & RM=Bald Eagle,Loc Hav         ,132363.8
39057.14999.83442812.5145429.4128074.97410612.67 13153.515707.1218245.4720772.43
23299.4425828.4628358.1630887.4433403.5135924.3838445.84 40963.943484.5746002.29
48523.9449627.9648733.7547828.66 46902.245937.3445009.1144106.3343235.1642370.54
41507.7640651.9339786.4838913.1238033.8637152.1636268.0635381.9934492.7933603.25
32716.3231827.9430944.4930053.3229163.8328274.7627384.0226494.4625603.9724713.89
23824.0122935.0222047.1821159.3320270.77 19383.418494.4917607.3416718.7415829.76
14941.1314052.02 13163.112274.0311385.4610501.63  9613.58726.2587838.1676950.494
6064.4325184.229 4298.083411.0482516.712 1629.17
River Rch & RM=Bald Eagle,Loc Hav         ,131699.7
38635.25999.81962754.4535376.108 8022.35 10560.813108.9415660.5718207.6320735.56
23262.9725794.9128324.8430858.2533374.3635896.3638418.0540936.86   4345845975.42
48498.4349632.35 48733.347815.4946866.0545871.6244941.1144045.38 43188.942335.32
41483.9540639.1639780.91 38912.7 38036.737157.1136274.91 35390.134501.3233611.65
32725.9431838.1130956.3430065.1729175.1728286.4627395.7526506.1925615.7824725.68
23835.6922947.1222060.0421172.6420284.3619397.2618508.7917621.7716733.2215844.62
14956.0414067.3613178.5112289.6511400.85 10517.69629.5378742.4797854.9126967.613
6081.917  5202.14316.0673429.3122535.4121647.969
River Rch & RM=Bald Eagle,Loc Hav         ,130997.6
38343.73   999.82667.975 5288.697939.05710482.9813040.1815598.4318155.2220684.41
23212.5825748.5828278.1630815.9633332.2935858.29   3838040899.77   43421 45936.7
 48457.749628.2148711.5747755.8446755.7945720.5544802.9743935.2843108.2442275.39
41443.57 40616.639770.2538909.6738038.6437162.7536283.75 35400.434512.3533622.24
32738.6931851.4530972.5230081.1829190.5928302.2727411.4226522.0725631.4524741.69
23851.5622963.8322077.7521191.0920303.5219416.61 18528.7 17642.316753.9815865.84
14977.2814089.1213200.1412311.9811423.3810540.589652.7918765.9197878.7916992.128
6106.8675227.8384342.1563456.0682563.2841676.661
River Rch & RM=Bald Eagle,Loc Hav         ,130339.2
38227.72999.78622580.4455185.749 7843.4410396.1512957.0215532.8518093.5820623.84
23152.7225689.8128219.3230764.95   3328135810.9838331.8840850.7143372.0545883.25
48398.1449604.83 48650.547630.3246559.9145485.1544601.4643781.1842996.7542194.16
41388.7740585.98   3975538904.7838040.4537169.3536293.9535413.1134525.5933634.68
32754.0431867.8430992.3330100.9829210.2528321.5527430.9826541.5525651.0424761.61
23871.1722984.6722099.7421214.0520327.1919440.8618553.6817668.0116779.8915892.42
15004.2614116.2113227.6612339.9911451.8110569.539681.9658795.8477908.7827023.042
6138.2965260.2514375.3243490.1932598.9971713.685
River Rch & RM=Bald Eagle,Loc Hav         ,129627.5
38184.89999.67032460.8125096.0367741.58710298.67 12864.215473.1218027.3120556.69
23084.7425620.0328150.3430704.3933218.9435749.0138267.8540784.8543305.4645807.55
48302.9749540.8948517.9247407.2546259.4445152.5844329.2343576.97 42850.842088.82
41317.4640545.39 39734.838897.56 38041.937177.04 36305.835428.5634541.5433649.64
32772.6431887.9631017.1230125.7629234.9228345.3827455.5526565.7825675.4524786.29
23895.5523010.2922126.9121242.93 20356.519471.6918584.9417699.6416812.3715925.46
15038.0314149.9613262.3612374.7911486.8210605.589718.622 8833.147946.5477061.763
6178.2975301.3474416.8113533.1682644.0351760.578
River Rch & RM=Bald Eagle,Loc Hav         ,128760.7
38126.56999.51412315.0124979.9527597.043 10187.612752.3415384.9417931.9620463.04
22988.3625519.7728051.55 30610.633126.2935654.4638170.47 40686.643202.0645686.06
48134.3449399.1948264.6647035.2545808.4644681.15 43953.843299.4442654.0741947.13
41220.9140489.6139707.5138887.06 38042.737186.1936321.16 35448.234561.9633669.16
32796.9431914.08   31050   3015829266.27 28376.927487.7726597.3225707.2524818.29
23927.3323043.7722162.6621280.7920394.8519511.8918625.8617740.9616855.2215968.73
15082.1314194.1613308.2312420.4611532.8810652.829767.3718882.1847996.6157113.243
6231.3115355.3094472.3323590.6012703.5071822.396
River Rch & RM=Bald Eagle,Loc Hav         ,128280.7
38084.69 999.509 2224.924891.1487492.30510125.2512683.9615313.0117863.2820397.89
22923.0525452.2927987.4130547.9633065.98 35594.238109.1340625.52 43135.545605.94
   4802149297.1748094.61 46802.645537.1444403.6843735.3343137.4442539.8441864.37
41164.2540457.4639691.1938880.77   3804337191.0736329.7135459.2934573.6933680.51
32810.88 31929.331068.9130176.2729284.2128395.2227506.1426615.32 25725.524836.48
23945.6523063.4222183.34 21302.620416.7619534.4618649.1517764.75 16879.515993.57
15107.1114219.7813334.5312446.7911559.4510679.779794.6748910.3458025.5477142.936
6261.5055385.7644504.2143623.3072737.283 1857.84
River Rch & RM=Bald Eagle,Loc Hav         ,127410.9
38098.58999.55742033.5244721.1257312.77310003.9212558.4815179.84 17745.720283.66
22813.8725341.9327885.1130447.4632968.7735498.4638012.4640527.4843026.14 45472.3
47830.5749111.8447799.9546400.0345073.2943932.6743366.6842861.0542345.8241724.52
41059.3640397.9839660.3238869.4238043.3937200.0436344.7435479.3334595.0733700.87
32836.2331956.6531102.4530209.7729317.48 28426.127536.8326645.3225755.7924867.19
23976.7423096.1122218.1221338.9120453.9119572.5718688.3317805.1416920.31 16035.6
15149.0114263.3113377.7812491.1811604.2310725.089840.2918957.4298073.8197192.464
6311.6795437.4024557.2283677.9972793.8121916.799
River Rch & RM=Bald Eagle,Loc Hav         ,126741.0
38029.56999.72111938.3854603.0147210.1749921.25312484.0415104.73 17679.520218.94
22754.6325283.4327828.1630392.1532915.9935446.7837960.23 40468.842959.1545388.96
47709.78 48982.747608.0946138.2144765.5543621.0243124.1142680.2942218.7341630.48
40987.5840356.8139638.9338861.1338043.4137205.8836355.2835492.88 34609.4 33714.6
32853.4831974.9231124.9630232.5429340.0228446.4327557.0726665.1225776.04   24887
23996.78 23116.922240.5421361.9620477.8919597.2918713.8717831.2316946.6616062.31
15176.5414290.8913405.7412519.8511633.3310754.51 9870.318987.5228104.4217224.002
6344.2075471.0754591.4653713.4062830.3661954.712
River Rch & RM=Bald Eagle,Loc Hav         ,126454.1
38002.28999.81351897.0574562.5747179.0249895.515 12462.515083.3517660.2420200.73
22737.33 25266.527811.48 30375.932900.3735431.4237944.6640451.07 42938.345361.45
47669.0948938.4147544.5446057.0244670.51 43524.143049.2342623.9742179.1341600.71
40966.8940344.9939632.7138858.4138043.2937207.3536358.2535496.5934613.4133718.56
 32858.331980.1331131.5530239.0229346.42 28452.727563.3426671.2425782.36 24892.9
24002.9223123.3122247.2121369.0120485.0719604.8118721.6917839.1416954.7116070.43
15185.0414299.3813414.4412528.7311642.1410763.279879.2828996.5848113.7267233.463
6354.1465481.2364601.8143724.146 2841.511966.396
River Rch & RM=Bald Eagle,Loc Hav         ,126062.6
37974.31999.92191844.0144520.8627145.012 9866.2112438.5215060.1817638.9320181.35
22718.12 25247.827793.2530358.1132883.07 35414.337927.3340432.9342915.9645330.22
47621.3548886.1747472.5645971.81 44575.743430.7542975.1842567.2142139.2141572.39
40946.9640333.5239626.5638855.7738043.0937208.78 36360.935500.0834617.1133722.23
32862.7731984.9631137.6430245.0829352.3228458.4127569.2626676.8725788.1824898.74
24008.9123129.5722253.76   2137620492.1619612.31 18729.317846.9816962.7416078.61
15193.3614307.8813422.7912537.2911650.6310771.749887.9689005.5088122.8467242.705
6363.8195490.9724611.8783734.6842852.3051977.356
River Rch & RM=Bald Eagle,Loc Hav         ,125704.7
 37946.51000.0331792.0314479.2867112.8389836.54312414.6315037.7417617.7220162.39
22699.8225229.9327775.7430341.0832866.8135398.2437911.0340415.3742893.3745298.46
47572.4648831.72   4740245891.8444486.0443344.0342904.7542513.5742101.5541546.25
40928.4240322.6839620.7438853.1538042.8237210.0136363.3935503.44 34620.533725.58
32866.9431989.5331143.0930250.4329357.7128463.7327574.6726682.1325793.5324904.27
24014.4223135.3422260.0421382.6220498.8719619.2618736.3917854.3316970.1616086.22
15200.9314315.4913430.3912545.1111658.5610779.84 9896.089013.9718131.3797251.448
6372.8895500.1074621.3433744.3962862.363 1987.38
River Rch & RM=Bald Eagle,Loc Hav         ,125091.9
37891.471000.1891660.3414386.8267058.9689783.58512368.1214996.7617578.9820126.13
22664.44 25195.927744.3330310.4832836.6135368.2837880.38 40382.242848.02 45229.8
47469.25 48712.847255.5545730.7344311.9343173.4942771.6242412.52 42030.841496.23
40892.8640301.9639609.7938848.2838042.1137212.3236367.8735509.5334626.7533731.84
32874.7231998.14 31153.330260.5229367.7628474.0127584.8626692.2525803.69 24914.4
24025.0923146.0722271.6521394.8120511.3919632.0718749.6817868.0916983.9816100.54
15214.9514329.5913444.64   1256011673.4710795.199911.5839029.8668147.4357267.909
6389.7215517.1934639.2353762.479 2881.332007.063
River Rch & RM=Bald Eagle,Loc Hav         ,124615.5
37905.631000.2671550.412 4289.527018.4979739.94312327.0414962.75 17546.520094.24
22633.2325165.8927717.5530284.2232810.0635341.7237852.6740351.6942804.31 45162.8
47367.8448595.4247116.2745579.5644152.69 43022.442654.0442324.4441969.0941453.08
40861.6840283.92 39600.238844.2338041.4437214.6236371.6535514.5534632.1433737.19
32881.3532005.41 31162.2 30269.429376.5828482.8927593.7426700.9125812.4824923.22
24034.1823155.4522281.6321405.2420522.1519643.4318761.2217879.8916996.0516112.77
15227.5514342.2713457.4512573.0811686.5410808.339925.1419043.4998161.4357282.355
6404.4455532.2474654.8833778.6312898.0862024.825
River Rch & RM=Bald Eagle,Loc Hav         ,124025.0
37863.641000.2581429.5884123.5456922.7039659.43212247.9614889.9417480.24 20029.7
22569.9625104.54 27661.730229.9432754.9735286.1537793.32 40282.242699.6445005.24
47139.3848337.7146821.2145266.2343829.5842720.3242415.66 42149.641844.1241368.08
40800.05 40247.839580.9138835.6738040.2537218.8136379.5735524.2934642.8433747.79
 32894.332019.6231180.05 30286.829394.0128500.4927611.1626717.58 25829.924940.84
24051.8823174.2622301.5621425.9720543.4619666.3818784.5417903.4517019.6916136.33
15252.3214367.3813482.96 12598.911712.6310834.489951.9899070.5828189.4067311.695
6434.131 5562.244685.7983810.6942931.1222059.657
River Rch & RM=Bald Eagle,Loc Hav         ,123503.5
37850.051000.1981396.8724049.6956857.7449617.13312204.8614845.5917442.9819993.46
22534.7225070.9127630.5430198.5132723.2635253.81   3775840235.2242626.7344895.72
 46993.448175.6146642.5545080.7543642.5542543.8442278.0842048.8341772.32 41319.5
 40764.140226.9439569.7838830.7438039.32 37220.736383.9535529.93 34648.833753.94
32901.8132027.7831190.4430296.7829403.7528510.4327621.0326727.0825839.8424950.81
24061.9923185.0122312.8521438.0120555.6119679.1918797.75 17917.117033.1716150.01
15266.3314381.5913497.1312613.5111727.4310849.629967.5319086.1838205.545 7328.45
6451.1945579.3314703.5063829.1362950.0832079.238
River Rch & RM=Bald Eagle,Loc Hav         ,123123.6
37822.841000.112 1375.953993.6156811.0779583.49512171.43 14810.8 17415.719966.34
22508.7425045.6827607.9930175.1732699.7935229.8737730.41 40195.942566.0744806.32
46878.0148049.8446507.9344943.4343505.8242416.0242178.2541975.6141720.2141284.53
40737.8740211.8939561.5738827.1838038.5437221.9136386.9335534.0434652.9833758.35
32907.2632033.5531197.8630304.0429410.8328517.4427628.0726734.0825847.0224958.06
24069.2323192.7922321.0221446.95 20564.519688.4718806.9717926.7217043.0916160.12
15276.41 14391.8 13507.312624.0511737.9910860.569978.6829097.4168217.2257340.295
6463.245 5591.824716.2843842.3632963.8112093.291
River Rch & RM=Bald Eagle,Loc Hav         ,122703.3
37836.29 999.9911349.4923932.6246757.0889542.97612132.5414769.9117383.8919934.72
22478.8125016.4627581.6830148.7932673.4135202.6337698.1640147.8942492.7144699.57
46742.0747905.2346357.2244792.3943356.3142277.5242070.7341897.8541663.7741246.75
40710.0540195.8539552.9338823.2938037.8137223.4336390.0835538.2434657.4233763.05
32912.9632039.6131205.6530311.7929418.4728524.9327635.6326741.6125854.7824965.87
24076.9323201.0422330.0921456.4820574.0719698.5118816.9117936.8317053.52 16170.7
15287.0114402.8213518.2812635.3711749.3710872.419990.7299109.547 8229.757352.994
6476.2025605.2014729.8643856.4832978.4522108.509
River Rch & RM=Bald Eagle,Loc Hav         ,122190.8
37822.88999.89021313.6193852.9576686.6739490.44912084.6914721.46 17343.419894.82
22441.7824981.5627548.24 30115.332640.29   3516837654.9140081.7242392.8444558.43
46567.2147722.1346169.6444605.9343170.86 42106.341939.6141802.5341595.9141201.42
40675.4140176.0539542.47 38818.338036.9437225.4236393.9235543.5434662.9133768.86
32919.8632047.14 31215.330321.28 29427.928534.2427644.8526750.5125864.1424975.03
 24086.223210.8522340.9821467.8220585.3419710.3318829.0717949.2317066.0516183.64
15300.1614416.3613531.8112649.1111763.3410886.7910005.429124.4578244.9587368.674
 6492.315621.6934746.7463874.0412996.781 2127.59
River Rch & RM=Bald Eagle,Loc Hav         ,121754.0
37809.13999.73251282.4433779.841 6628.319445.32512045.8614679.8117309.1419861.41
22409.8124951.9427519.6230086.73 32612.135137.6537614.8840020.6442300.7444433.54
46416.9147565.8246011.1944446.7643013.5741962.4441829.0241722.3241538.7341163.37
40646.0240159.1239533.5638814.0638036.2337226.95 36397.2 35548.234667.6233773.77
32925.6832053.5731223.4130329.1829435.8728542.1927652.7726758.0225872.0324982.91
24094.0623219.1722349.82 21477.420594.98 19720.218839.2317959.7217076.5416194.53
 15311.214427.6413543.21 12660.511775.25 10898.810017.679137.1118257.6237381.873
6505.7455635.4424761.0313888.7483012.2272143.513
River Rch & RM=Bald Eagle,Loc Hav         ,121394.1
37808.93999.53881256.2033718.4256576.3549407.18512013.0214644.6817282.08 19835.3
22383.4624927.8827497.1630064.3932589.7735112.8937581.9539969.4142224.2544332.35
46297.4147441.8245886.1744321.4342891.09 41850.9 41743.141659.8441494.1941133.79
40623.1240145.8539526.5338810.8838035.5537228.1536399.6835551.7534671.2933777.53
32930.2132058.5131229.68 30335.329441.8928548.1727658.7926763.7725878.0624989.15
24100.0723225.6522356.68 21484.820602.4919728.0318847.1817967.8217084.7816202.81
15319.68 14436.313552.0112669.3211784.4810908.0910027.089146.8388267.5637392.047
6516.1095646.0164772.0133900.0413024.0562155.743
River Rch & RM=Bald Eagle,Loc Hav         ,120862.6
37795.74999.3467 1221.843623.9396495.1529346.113 11960.314592.0717242.7719797.53
22345.6424893.0827465.0930032.5532557.2735076.5437531.0539889.4142107.09 44181.3
46122.4447261.9345705.78 44139.942711.7341687.1441617.1641565.6641428.4441090.32
40589.2440126.2739515.9538806.0238034.3537229.9236403.37 35556.834676.5733783.02
32936.9632065.7531238.9130344.4629450.7928556.8227667.4826772.0125886.9224997.91
24108.9523234.9822366.8421495.6120613.1819739.5818858.9717979.8617097.2116215.33
15332.3614448.7613564.9312682.43 11797.8 10921.710040.979160.8418282.2557406.803
6531.3295661.5344788.2083916.5833041.2612173.682
River Rch & RM=Bald Eagle,Loc Hav         ,120421.4
37769.57999.26061193.6343551.0386440.9379299.97711922.2114554.1117212.3319768.71
22317.2924866.9427440.8630008.5832532.5535048.0737487.8839822.0242009.62 44059.3
 45983.347118.8445562.7143995.9342569.1641555.5641515.0441488.5541374.61   41055
40561.0640110.0539507.2938801.86 38033.537231.3436406.3335560.8134680.85 33787.6
 32942.532071.7131246.4330351.9829458.1728564.0527675.0326778.6725894.1225005.11
24116.2823242.6122375.0721504.3320621.9619748.9318868.59 17989.717107.2616225.51
 15342.714459.0713575.6412693.2611808.6110932.6610052.269172.3118294.0197418.772
6543.7435674.2054801.3823930.2033055.2972188.331
River Rch & RM=Bald Eagle,Loc Hav         ,119954.9
37756.54999.15251166.4683475.7366392.9859258.007 11889.6 14522.517184.5219743.27
22292.2824844.1127419.2829987.5532510.3835021.2437442.9839753.2141911.1743938.34
45846.5546975.0745419.59 43853.242427.2741423.1541410.3341411.5941319.4941019.21
 40532.240093.6239498.4638797.6438032.6337232.7636409.3635564.8434685.1733792.25
32947.9832077.7331253.9530359.6429465.5328571.6427682.7826785.48 25901.425012.52
 24123.723250.3922383.5321513.1820630.9519758.5118878.3417999.4317117.3416235.59
15353.1914469.6813586.5212704.2711819.64 10943.810063.559184.1738305.9737431.128
6556.3055686.9394814.4623943.763 3069.552203.098
River Rch & RM=Bald Eagle,Loc Hav         ,119473.8
37729.56999.01981141.6293414.698 6344.449216.74711855.22   14491 17157.819718.51
22267.84 24822.3 27398.8 29967.232487.6334991.9337389.6839671.3741796.85   43801
45693.2846812.97 45254.543687.1142261.1741270.1641289.9341324.9141256.9540978.53
40500.7540075.6639488.4638793.0238031.61 37234.336412.59 35569.234689.84 33797.4
   3295432084.2431262.2530367.8829473.51   2858027691.3526793.25 25909.625020.86
24132.0323259.15 22393.321523.4920641.1219769.3418889.44 18010.417128.79 16247.2
15364.8114481.6813598.5512716.6411832.06 10956.510076.659197.587 8319.487445.213
6570.6285701.1874829.202 3958.86 3085.542219.821
River Rch & RM=Bald Eagle,Loc Hav         ,118901.0
 37743.1998.91041121.1883361.5286287.7419167.47911811.1414452.2117126.3419688.02
22237.8624796.4327375.4729942.64 32457.134943.39 37301.839538.0541617.3443594.43
45466.9546570.0745011.43 43448.742026.4741055.7541124.8841206.1841173.1540923.92
40458.1540051.2339475.07 38786.538030.3537236.3736416.7635575.2434696.1233804.36
32962.1832092.9931273.5930378.9129484.3828590.9227702.4826803.6425920.5225032.18
24143.2823271.0922406.2721537.3920654.8119783.8518904.3718025.5417144.4116263.08
15380.5514498.0313614.9512733.5611849.2610973.8810094.769215.7058338.0867464.339
 6590.295720.9014850.0163980.2953107.6112243.024
River Rch & RM=Bald Eagle,Loc Hav         ,118300.5
37715.95998.95651104.1873284.9476234.0789118.82511770.5514410.7917095.59 19657.8
22208.5824768.0727351.7729916.2532418.8834867.28 37172.339354.6941392.1343342.34
45195.29 46282.144734.0243182.9341767.2540820.48 40946.641076.6441082.6940864.97
 40411.640024.6139460.7338779.43 38028.737238.6236421.2535581.6634702.9633811.91
32970.9732102.5131285.7430390.9329496.2928602.5527714.3126814.9425932.4725044.17
24155.6523283.9122420.2821552.15 20669.519799.4218920.3718041.7817161.49 16280.1
15398.1514515.5113632.6912751.8711867.9910992.9910114.239235.2818358.3227485.151
6611.4735742.5214872.916    40043131.7022268.264
River Rch & RM=Bald Eagle,Loc Hav         ,117753.9
37729.16 999.113 1086.64 3207.756197.5159077.47411739.4814377.5817066.4219629.11
22180.8224741.6427327.4929887.5332371.13   3477537022.9739161.3641172.2743099.82
44937.5346021.1544486.3642947.3241539.8140617.3540793.6140965.28 41005.140814.58
40371.8640001.9639448.4738773.6338026.9337240.6336424.8835587.1934708.7933818.46
32978.4732110.54 31296.230400.9729506.4328612.4727724.5826824.3825942.93 25054.1
24166.2323294.6922432.0321564.6720681.8719812.6918934.1518055.5517176.0616294.59
15413.2114530.5713648.0512767.5811883.9211009.2410130.839252.2238375.6787503.028
6629.7985761.2144892.2434024.214 3152.742290.214
River Rch & RM=Bald Eagle,Loc Hav         ,117180.8
37703.07999.28081072.4933138.192 6159.929035.21511700.7314341.5517033.6919596.42
22148.9324711.3527295.9529847.8532298.0834643.1836826.7638928.6640913.7542822.57
44644.9645730.8444213.7642689.7441294.1840399.83   4062940846.09   4092240760.66
40329.5139977.7739435.4538767.5338025.03 37242.436428.9135593.2134714.96 33825.5
32986.4532118.9931307.3430411.7329517.1928623.4427735.5426834.2325954.0825064.98
24177.3623306.1922444.3421577.7920694.9619827.1218949.0618070.7117191.3516310.22
15429.2414547.0213664.63 12784.211901.0411026.49 10148.6 9270.448394.3317521.991
6649.4285781.3134912.8584045.9753175.5052313.912
River Rch & RM=Bald Eagle,Loc Hav         ,116401.3
37741.27999.4307 1059.222999.3746082.9458964.09711627.8614276.8116983.6119545.08
22098.8124658.6227241.5729770.7332149.21 34386.736483.2338544.0740497.5142387.16
44193.2545282.12 43792.142290.6140912.5640060.54 40370.240657.8440790.68 40675.5
 40262.239939.7939414.9838757.9638022.4837244.6136435.5635602.0534724.8433836.39
32998.8532132.5131324.6130429.0829533.86 28640.827752.6826849.7525970.9925082.31
24194.83 23324.522464.4921598.8720715.7719849.9918972.2118094.6317215.4416335.11
15454.5514572.7313690.7312810.4411927.7411053.9310176.329298.9878423.475 7551.81
6679.7825813.0634945.5474080.323 3211.092350.749
River Rch & RM=Bald Eagle,Loc Hav         ,115584.2
 37689.2999.66931044.3432833.2665987.7618873.83611544.0114199.4216924.5119483.79
22039.8824596.9927173.9929665.8831949.5134071.4136092.3638120.3140036.9841904.84
43701.1344788.7943326.9841848.5440488.36 39681.640080.6940448.09 40643.440580.13
40186.7839896.9639391.6638747.17 38019.437247.5536442.9635612.2734735.7433848.63
33012.6732147.7431343.8430448.2929552.6728659.7227771.7326866.8925990.1625101.37
24214.3523345.3222487.0621622.6620739.21 19875.418998.13 18121.317242.6816362.72
15482.54 14600.913719.9112839.9111957.51 11084.910207.159331.3858456.2987585.177
6713.8895848.246 4982.144117.8713250.8652391.457
River Rch & RM=Bald Eagle,Loc Hav         ,114899.8
37702.31999.78251030.9732735.0545911.5678800.235 11482.914137.5216874.2119432.59
21992.2424546.2527112.9129561.7631763.0733801.6835776.5637774.6939655.9441500.87
43285.8344367.3342930.6441472.3540128.4139360.5139835.48 40271.840518.8740499.57
40122.9339860.4139371.9138737.6638016.9537250.45 36449.235621.1934744.8633859.05
33024.3332160.4531359.9330464.48   2956928675.9227787.9126881.3526006.9225117.58
24230.5823362.7822505.8221642.5920759.1319896.8919020.1918143.7817265.8716385.98
15506.1714624.8613744.1512864.4611982.5511110.6410233.569358.7598484.1217613.451
6743.0065878.1035012.7424149.1833284.1052425.973
River Rch & RM=Bald Eagle,Loc Hav         ,113985.6
 37739.9999.45511019.6862624.8455802.2548700.17411409.6714063.0316805.9119366.67
 21931.224479.4727026.5929400.7131499.4533448.2535375.8537333.5339154.6340958.71
42709.9343768.1442367.1140937.5339615.9838902.95 39485.240017.9640340.6640385.08
40031.6339808.8439344.4938724.1738014.0537254.4536457.6635633.7534757.7933873.76
33040.8232178.8431383.2830487.4629591.9928699.4627811.2226902.2726030.2325140.86
24253.3423387.5822532.9621671.1820787.5119927.6319051.2718175.7117299.0416419.09
15540.4314659.2113778.5612899.6812018.56   1114710271.269397.0728523.9327654.142
6785.1065921.2395056.7514195.2543330.868 2475.49
River Rch & RM=Bald Eagle,Loc Hav         ,112856.9
37714.86998.59011011.1432521.219 5670.37 8575.1711325.1313976.1816721.4119291.34
21857.36 24396.2 26904.7 29168.831151.71 33009.7 34876.736761.4438518.18 40274.5
 41977.343002.0541643.8640247.0138952.0338307.2339030.7739687.6640110.6340236.33
39913.1639742.6439308.4938706.9538010.2437259.1936468.9835650.1834774.6333893.09
33062.21 32202.931413.1830516.9529621.8428729.5127841.1926928.9526059.9825170.76
24283.4823419.9122568.4421707.5220823.5619967.4619092.2918217.6117341.8416461.91
15584.5114703.3413823.4312945.8112065.8511194.8810320.37 9446.868575.5347706.843
6839.9445977.2175114.8524254.9733392.4812539.906
River Rch & RM=Bald Eagle,Loc Hav         ,111971.0
37714.16997.61421005.9142451.3635557.9168465.47311251.3313899.8816645.0719225.28
21790.6224318.25   2677828931.8430815.6232595.3434402.6836225.0237954.64 39683.2
   4135942364.0741042.7639670.8438396.0937808.0938650.1539411.1839918.6940111.15
 39813.739686.4739278.6138692.9138006.6637262.9136479.3135663.5834789.0433909.75
33080.2632222.8231438.3730541.8729646.5828754.2427866.0726951.5426084.9125195.28
24309.1123446.85 22597.321737.9620853.6220000.6819126.3218252.8917377.3116497.83
15620.8914740.7413860.9512984.4612104.9911234.9210361.759488.6148618.3897750.874
6885.2496024.0495163.4554304.1953443.9852593.792
River Rch & RM=Bald Eagle,Loc Hav         ,110657.4
37712.96996.44681002.2372303.1925361.3068301.62411117.9713780.0816523.1719120.09
21686.2624174.5826537.6428505.3430221.1131852.5733567.8735338.2637047.2538737.25
40385.0441377.7640117.1438787.0537550.3637047.3238064.6938987.3339623.5639918.25
39658.5439598.6639232.2738670.6738000.9837269.2536495.2235684.4234811.31 33935.6
 33108.5 32253.331478.31 30580.6 29684.728792.0127904.69 26986.826123.26   25233
24348.08 23488.222640.71 21785.320900.24 20051.2   1917818305.9717431.5716552.72
15676.6714798.8313919.2913044.1412165.3811295.8310425.169552.8458684.5387818.376
6954.0126094.5025236.4474379.5243521.5732675.871
River Rch & RM=Bald Eagle,Loc Hav         ,109659.9
37701.89996.2764 1001.252233.1865212.2578208.30911023.0313690.3116429.63 19044.9
21610.7124056.5226306.1728128.1829717.5731246.9432904.6234638.8536344.6638000.33
39624.6840614.9839398.07   3810236902.3436463.5137613.7238663.9539397.2139770.29
39538.7639531.1539195.7938652.7137996.8837274.0236507.2235700.3634828.4833955.15
 33130.232277.0131509.1230610.6329714.7328821.6527934.62 27012.926153.0425262.63
24377.8523519.66 22675.121821.2220936.0120089.7319217.7218346.5117473.3216595.15
15719.3214842.2613964.6413090.0512212.4611342.4210473.499602.1748735.5877870.542
7006.7816148.009 5291.464437.2933581.5462738.657
River Rch & RM=Bald Eagle,Loc Hav         ,108600.1
37701.07996.77421000.3912273.6455036.2148137.97610937.0813575.8716309.0118959.18
 21520.423907.8825984.5727643.1529104.8130554.7432160.2533850.1535539.8637171.13
38767.5739755.9138589.3837333.1536169.4135811.6437113.0938304.4239146.6139604.39
39407.3239457.1139156.6238633.1337992.2237279.25 36519.435718.0234847.1233976.86
33154.1832303.03   3154330643.0529748.0628854.8327968.0527042.1926186.6425295.44
24410.8823554.56 22713.821861.1520976.1820132.67 19261.318391.7217519.9316642.47
15767.3614890.1314014.48 13140.712264.6111395.0710526.879656.8998792.9147928.762
7065.8316208.221 5353.49 4502.043648.6952808.923
River Rch & RM=Bald Eagle,Loc Hav         ,107333.6
37700.06997.3465999.82852174.2434841.571 7974.8710792.3913411.0316135.1418806.62
21364.21 23627.225460.8926926.3828266.3529636.3831163.1132797.7634458.1336082.43
37646.89 38637.437539.8136335.9735218.6434968.0536468.9937841.2338824.1639388.34
39237.9139362.8739106.6338608.3837986.3437286.3236534.2635741.2934871.0434005.31
33185.4732335.8731585.34   3068529790.1228897.7628010.5227081.3226229.9725338.04
24453.4423599.5822762.6121913.1821028.4420187.4119317.87 18448.717578.8716702.33
 15829.614952.4214077.56 13206.212330.6411462.8110595.33 9728.398867.041 8003.57
7141.7146286.2735434.1554585.1393734.7572899.696
River Rch & RM=Bald Eagle,Loc Hav         ,106466.0
37711.87997.4329999.7454 1996.78 4716.25 7796.5510641.5913278.8615995.6218665.17
21211.6723349.2324988.9926330.3627597.8228929.3830411.2232019.7933664.9935284.76
36826.0337817.2736770.0735606.4934523.6734350.0536000.2137503.68 38588.539231.31
39114.78   3929439069.73 38590.337982.2337291.1336545.3935757.1934888.4834026.14
33207.8732360.0831616.0330715.5729819.9928928.4228041.09 27109.426260.4125369.02
24484.9423632.6222797.8821951.2221066.0920227.1619359.32 18490.417621.8916746.19
15874.9314997.7314124.0113253.8412378.4511512.34   106459780.8318919.8958057.852
7196.9056343.4585493.2634645.6333798.2032966.166
River Rch & RM=Bald Eagle,Loc Hav         ,105178.6
37710.63997.5222 999.4981736.1254530.3847549.18110386.6813074.5215779.4818455.67
20907.55 22806.724108.5325278.1126429.54 27703.729113.3730671.3732268.6733835.24
35283.1836298.1435299.0234197.2333159.8433146.2735081.7536842.0638125.4638922.94
38875.1639158.0738996.0238554.0637973.2137300.7536568.0135789.2434921.8634066.03
33250.8832407.5731677.1630776.09 29880.428987.4928102.32 27165.326318.9625430.63
24546.88   2369722868.8822025.2721140.9920306.7319441.3718574.4817707.7516832.28
15962.0715086.88 14215.413345.8312472.31 11609.610743.679882.8189022.626 8164.57
7307.1776455.7545609.3824766.9053924.2373096.915
River Rch & RM=Bald Eagle,Loc Hav         ,104647.2
37700.62997.5623999.39121639.9594464.4967469.29810310.2412998.9815700.7318380.66
20791.39   2258523769.71 24887.626004.4527256.6928625.7830116.3131670.3733204.12
34609.95 35640.334659.3833582.6632563.2532620.3334676.9436551.1437918.4638784.91
38768.3539097.5438963.2538538.13 37968.5   3730536578.1835804.3234936.7534083.77
33270.3432428.4731704.3630803.3929907.7329014.5528129.5327190.4726345.6125457.96
24574.0623725.1622900.3122058.5721174.9620342.5219478.0418611.23 17745.316869.89
16000.46 15125.814255.5513386.4512513.8111651.8110787.099927.1729068.4948211.871
7355.4926505.039 5660.534820.2943979.424 3154.14
River Rch & RM=Bald Eagle,Loc Hav         ,104195.0
37688.48997.5778999.38231544.5494387.1087393.28210257.4212941.5615642.4218314.32
20705.9722419.4423520.94 24599.325695.2626929.5128269.0929717.2131238.3132754.79
34143.9935179.0134222.3833162.1932160.9132258.3334401.18 36351.537776.0138690.09
38695.2739056.1738941.2738527.5537965.1737307.66 36585.4 35814.834947.2334096.11
33283.7932442.7531723.0430821.7229926.0829033.1528147.7827207.5326364.0625476.32
24592.2823744.8222921.4322081.4321198.3220367.0419503.1218636.3717771.0616895.78
16027.4315152.3814283.0413414.3812542.7811680.9910816.699957.692 9099.768244.027
7387.7826538.688 5695.744856.1614016.9343193.006
River Rch & RM=Bald Eagle,Loc Hav         ,103854.0
37667.46997.5562 999.3351460.573 4307.667322.10110204.3812897.2915597.7518262.77
20630.49 22285.723318.4424358.6925439.2626665.63 27988.529432.1830940.2432444.36
33821.8434856.4733916.59 32870.731879.3531998.6634206.4536208.21   3767638623.35
38644.13 39027.438925.74 38520.237963.1537309.4636590.5535822.1434954.6334104.89
33293.1632452.7831736.3230834.3129938.8529045.9628160.6527219.4626377.0325489.27
24605.2323758.9122936.5622097.2521214.7220384.47 19520.718654.6717789.28 16914.4
16046.6315171.6414302.6413434.6612562.9911701.8710837.899979.2819121.809 8266.55
7410.8116562.569 5720.634881.8094043.473 3220.83
River Rch & RM=Bald Eagle,Loc Hav         ,103369.7
37699.67997.5283999.26681383.3124213.2617244.10210140.0712844.2515544.0818201.17
20535.9222118.8523075.7824068.4525117.8926317.3827606.1329043.7530526.4232003.25
33350.1834372.1933456.6332432.2531456.8431611.3733915.9835993.3437526.3838523.42
38567.2938977.7738898.7438507.0637959.7637312.5936599.4135834.7634967.2834120.14
33309.6632470.1431755.9730853.43 29958.429065.2728179.97   2723726396.5825508.59
24625.0123779.9622959.27 22120.8 21239.420410.3819546.7118681.6517816.75 16942.7
16074.9115200.4314332.4713465.3712593.1811733.1610869.3610011.399154.8598300.138
 7445.136598.459 5757.13 4920.294082.8933262.686
River Rch & RM=Bald Eagle,Loc Hav         ,103122.3
37699.45997.5309999.25251366.8314192.5587228.57510127.7112832.8515532.5218187.08
20510.73 22066.523005.5423984.2125022.3626213.4327496.6728932.18 30410.131881.82
33220.6934247.2833346.9132327.9131338.7531476.8833815.2435904.3437464.3338482.03
38535.3838956.8938886.6638500.6637958.0637314.2136603.3735840.3834972.7134126.27
33316.4332477.3631764.03 30861.329966.33 29073.128187.8527244.3626404.5825516.57
 24633.123788.5922968.4722130.5921249.5720420.94 19557.518692.5917828.2416954.33
16086.5515212.0914344.7413477.8212605.7811746.1710882.4710023.649166.1438311.673
7456.9626610.8325769.7744933.6414096.5613276.967
River Rch & RM=Bald Eagle,Loc Hav         ,101440.3
37696.08997.2149999.19131249.6583928.7977058.2649993.34212694.1115400.8118027.73
20069.5221175.6421884.51 22695.323612.8124757.6426043.0227435.35 28869.330284.91
31514.6132350.3331472.5730577.2129675.32 29988.232702.5135092.2536899.6938101.84
38246.1638791.5538784.8438450.5137944.9837329.7136633.6135883.6935017.8334174.42
 33369.532533.5131837.4130932.7930036.4629144.1228258.0827313.3726477.86 25589.5
24706.56 23867.523052.33 22220.221341.4620515.0919655.6918792.3117931.87 17058.9
16193.2715319.6414454.6813589.5312721.5811863.7711004.0110146.199290.7178438.841
7588.7356746.0185908.4375079.2434248.6473434.076
River Rch & RM=Bald Eagle,Loc Hav         ,100657.3
 37687.7996.7958 999.033 1186.543782.2626959.1919913.89612626.2315344.3417923.06
 19764.320709.1821377.43 22168.123060.0924166.5925411.44 26724.128120.8229516.27
30692.4531453.3430600.4729755.4928899.4729290.1332178.48 34711.536634.9937922.96
38110.1238714.3638742.6838429.5937939.4937335.0636646.3635901.5335036.3434197.47
33394.1532560.2831871.4430966.3730069.77 29177.928291.1927346.6526511.8525623.58
24740.9223904.7423092.0522262.0621385.13   2056019702.4418840.0717979.5917107.66
16242.8315369.3914507.0813642.2512775.7211918.9211060.9210203.779350.4748499.281
 7651.186809.589  5974.55146.9784320.2263508.785
River Rch & RM=Bald Eagle,Loc Hav         ,99452.75
 37676.9996.1938998.72571105.5073402.2696755.196 9753.7512487.5815241.8217670.72
19134.7619913.8520585.8621359.2122212.8523210.1324395.5325496.5526768.5528135.17
29252.2730026.2629257.6428490.5727704.3428212.3131369.63   3411836221.8437644.63
37898.1438595.4138676.6638396.9837930.3137342.0936666.65 35928.835065.8834233.09
33432.6432601.7231923.8431018.8430122.0929231.12 28343.427398.3426564.8325677.15
24794.7723962.1523152.4722326.0421454.3620631.6919774.62 18913.818054.5117184.29
16320.0715446.0314588.9413725.72 12859.612004.78 11148.510291.589442.6758592.614
7746.455 6908.036076.7165252.7114430.2483623.873
River Rch & RM=Bald Eagle,Loc Hav         ,98206.87
37694.71996.1346998.47051055.4842982.3156513.1729563.26112324.1615112.6117290.77
18242.5118799.99 19468.4   2022121048.5922010.9323175.1224141.9425314.6326636.02
27713.2328511.6827823.0627152.0126407.6127042.8230494.8733475.4935775.6737342.31
37670.6238465.6138605.0238361.2737920.23 37349.836688.2735957.9635098.0734271.55
33474.6732646.3631979.6631074.8730179.0829287.9628400.25 27454.626623.25 25733.6
24853.3824021.8323216.8922396.0821528.9920709.0919852.1318993.7118135.7617267.71
16404.8315529.0814675.8413816.04 12949.912097.33 11243.110386.81 9541.288692.467
7849.5817015.5416187.019 5367.074549.8213747.454
River Rch & RM=Bald Eagle,Loc Hav         ,97607.35
37686.55996.2665 998.3371041.5252869.4246428.8089495.85612273.1115059.0317111.87
17870.9518328.9118980.4819692.9620499.9721467.6322615.5823563.1424728.1626040.27
27103.7927902.5827231.6126583.8325838.6626531.5730109.2833196.3235581.5337210.11
37572.0638408.93 38574.538345.4437916.0937352.91 36697.335970.9235111.8234288.24
33492.8632666.0932004.4431098.8330204.3329312.6328424.65 27480.326648.4225758.03
24878.6924047.97 23244.822427.1821561.7320742.4219885.9119028.8918171.1517304.25
16442.1615565.1114713.4813855.24 12988.712137.91 11284.110429.089584.7368736.701
7894.9717063.2196236.0495417.3634601.7913801.528
River Rch & RM=Bald Eagle,Loc Hav         ,96370.43
 37685.1996.7385998.10791028.3992688.516 6289.789385.25512208.4814786.5916474.49
17054.5717414.59 18043.518664.55 19398.5 20323.8 21440.4 22348.423467.6324728.78
25777.2126561.4125944.7725344.89 24631.225453.2329292.0232606.5635166.0936927.29
37363.5938288.11 38509.238311.2737907.1337359.3336716.3335998.8635141.3234323.54
33531.8232707.5132058.8831150.9830256.7229365.8628477.5127536.4626701.5425811.77
24933.4724104.3323306.2522492.8821633.0720812.1919958.0119103.3818245.8717379.85
16521.1315641.6414793.6113937.6513071.9212223.5411370.9510519.669675.9328829.481
7992.105 7162.276339.6745524.3564712.0013915.683
River Rch & RM=Bald Eagle,Loc Hav         ,94560.01
37682.87998.0103997.76951015.4462279.9216079.4029201.34111908.8713818.7615001.35
15473.4615774.3416365.9316958.7517621.3118486.2319539.31 20375.721396.68 22542.7
23592.6524352.6623810.7323330.1222722.3823751.0328010.2731681.3534516.0536484.34
37038.1838097.78 38406.738257.2337892.9737371.5236746.5236043.5435187.3434379.02
33592.5932771.9432143.4531232.8530338.1229448.6228560.3427625.2426785.68 25895.5
25018.4824192.2823404.8322595.7321744.6120921.9820071.16 19220.318363.3817497.98
 16643.215761.0914920.4614066.8513202.5412356.7611509.4510661.459818.5818974.728
8144.842 7317.026502.3635692.5994885.9494096.818
River Rch & RM=Bald Eagle,Loc Hav         ,93391.71
37649.07998.8817997.61961009.3242034.8765956.9029060.72211514.4413028.0714091.79
14559.1614878.5915458.94 16072.516704.2117560.8418597.4919407.04 20362.221475.48
22481.4823204.5122701.1822253.42 21702.122819.5627312.3731170.7134161.4936241.61
 36860.837993.9138350.3538227.8837885.8437378.7736762.5636068.2335211.9834409.07
 33626.132807.3632188.7931277.0630382.9229492.8928605.33   27675 26831.325940.91
25063.71 24240.923457.86 22652.521804.3920982.7320132.9419284.67 18428.317564.72
 16709.715825.78 14991.314138.3413274.0612430.3111584.5610737.689896.2719055.213
8227.6477401.9636590.3915784.0684980.0354196.442
River Rch & RM=Bald Eagle,Loc Hav         ,92011.85
37655.43999.9923997.54991003.8771741.2555802.2958858.53510931.4112175.3313163.97
13628.5113972.2514609.1515226.4115809.1816643.4317684.8818437.7419321.61   20425
21341.04 22015.821597.17 21161.720672.9621855.9326593.4230642.6733787.3635984.74
36675.5337885.0738291.06 38197.237878.2737385.7736779.5636092.9635238.3434440.23
33661.6532844.5432235.7431322.8230429.3229539.2928652.6227727.7826879.1925988.81
25111.5724292.0623511.9522712.88 21867.421046.2820198.1619351.8618496.3317634.71
16780.73 15891.815064.3714211.7413348.1312506.4811661.5710815.569977.3969138.736
8314.0317489.2766680.2275877.9055078.7464298.872
River Rch & RM=Bald Eagle,Loc Hav         ,91030.01
37666.55 1000.62997.60151001.3791561.9095716.8818671.11910486.5211612.8912560.46
13027.8313382.9314074.1814664.1315200.8516029.06 17043.7 17746.418615.24   19690
20561.4621234.11 20842.620364.7519920.7821113.8926040.33 30243.333477.0435771.88
36521.6837794.8638242.1338171.2637871.7237391.33 36793.736114.0535260.8734466.31
33690.5632875.7532275.8231361.0430469.32 29578.728691.5327771.7226920.0726029.17
25151.8824333.89 23557.322762.24   2192021098.5920251.2419402.2918547.7617686.82
 16834.415941.2115118.9714267.3713404.7712564.0611720.6110875.7810039.729202.652
 8380.177556.289 6750.265950.1145154.2014377.656
River Rch & RM=Bald Eagle,Loc Hav         ,90096.99
 37665.31001.138  997.911000.8921495.1885638.3058361.7039975.38511009.9611906.24
12374.31 12751.513496.4314071.4414567.3915384.1316373.8916991.4317811.9618859.26
19656.0320300.1119949.6219416.1819024.5420225.1225377.7829765.6733106.1335516.77
36337.6737686.8838183.6638139.3637863.7937397.4436810.6636139.18 35287.334497.17
33724.7632913.3832323.7931408.12 30517.429625.9528737.5827824.1426967.5926076.88
25199.64 24383.423611.3722819.9921982.6721161.47 20315.519464.49 18610.117750.18
16896.67   1600015184.3514333.9413473.1912632.89   1179110947.8310113.989278.842
8458.4597637.1866834.9316036.2035244.0694472.095
River Rch & RM=Bald Eagle,Loc Hav         ,89060.69
 37680.41001.995998.58311000.7451432.2055449.6547864.2369296.44410235.3911088.19
11561.4411973.6712751.9113312.9213806.1114542.6315468.7416021.19 16728.617708.71
18438.8119000.3318688.5518190.5817817.4119112.4524510.4829140.4332657.0435207.82
36114.7737555.8538114.3138101.1237853.0937406.7436831.8636169.1835318.7534534.22
33765.8232958.5432380.5531464.8730574.8329682.6528793.52   27886 27025.226132.97
25256.5224443.45 23676.322890.0322058.0821238.6720394.9519546.0418691.9717834.08
16978.0916077.8815269.2214420.9413561.39 12723.211883.8411042.2110211.169378.478
8560.7667743.0746938.9666144.7275356.9724591.359
River Rch & RM=Bald Eagle,Loc Hav         ,87861.14
37655.591005.4091001.5141002.7571371.4375015.2767116.3418373.9219227.11910060.07
10558.5910926.0211745.3312244.8512713.2213395.1514202.0214727.6915378.2816235.65
16911.6717455.5117143.5916707.4816359.4917784.2623476.3928394.0432125.4634843.05
35850.9437400.0438032.3538056.7137840.5637417.7536857.6536204.4335356.6434578.69
33814.6633011.8932447.5131530.9330642.6729748.0128859.9627957.2127094.1726199.54
25323.32 24516.923754.8722973.5822146.25 21327.220485.4419640.4218787.3717931.63
17076.0216171.7815370.5714525.4513664.8712830.0311994.0311155.3310326.569497.345
8683.8877867.9077062.754 6275.155492.6764734.233
River Rch & RM=Bald Eagle,Loc Hav         ,86942.04
37648.141010.8191006.3521006.3471314.8614541.7036400.8337526.951 8334.879161.073
9698.23210002.9510774.9311266.7211674.3412345.8813123.47   1359814225.6215041.71
15641.67 16193.915934.6615517.0315235.0716734.2122693.6827815.3631712.9834560.18
 35647.537279.9137967.5738021.8137831.8237424.0336877.0536231.4335386.1134613.26
 33852.433052.9632500.0531581.8230695.4329799.1328910.6328011.1327148.0426250.46
25375.5924574.0623817.2723037.6722214.9621394.5720555.1119713.2718860.8518007.02
17151.1316246.02 15450.914606.0713745.6112910.5312077.3211240.8310414.379588.134
8776.153 7962.457162.6436377.6085600.1834847.356
River Rch & RM=Bald Eagle,Loc Hav         ,85569.53
37663.731019.1361014.0661012.309 1241.433706.102 5199.276141.2516876.6247603.356
8051.6578286.4848887.7099388.9749768.57710354.4611084.0511545.6712084.4912839.92
13375.4613909.5713759.2813440.3313230.2414914.4221292.91 26783.5   3099134064.55
35284.6937069.44 37853.337962.2237816.5837437.5236911.2136282.0735437.5134673.91
33918.4333124.8832594.6731673.9230789.5529891.9428997.6728104.9427242.4926335.15
25467.8224672.3523925.5323150.1522334.0221515.8820679.63 19840.818991.5918140.15
17285.3516383.1615593.4414750.8413893.2213055.5612227.1411394.1910571.76 9749.82
8940.3818132.4617338.9036561.9735792.5625048.528
River Rch & RM=Bald Eagle,Loc Hav         ,84724.08
37662.23 1024.35 1018.731015.9961198.4623160.4944442.2195281.8985963.0236602.033
6962.6067164.1947677.0998145.3998551.576  9080.59752.065 10211.610725.4211416.35
11943.0912474.1812367.9112139.3311954.2113780.8920407.1726143.9830543.1133756.81
35055.3736935.6837780.86 37926.3 37807.237447.0636933.3636314.0435470.2134712.41
 33960.133170.1832654.2931733.7230848.2629949.0229051.95 28162.727301.9326386.08
 25524.624733.0423992.3423220.91 22407.121591.4220756.9119918.8219072.3618222.05
17369.1216471.5315680.3614842.2813984.3613147.6312321.09 11491.110671.639851.705
9043.7968239.6757450.2036679.2445914.241 5174.47
River Rch & RM=Bald Eagle,Loc Hav         ,83563.41
37656.56 1033.351026.7121022.2931125.6912364.7163336.5884006.1254614.2725220.815
5610.6645886.5396292.8556714.4447106.1867618.9788214.5018621.9469146.599 9747.35
10223.5910778.9910717.3410557.8910432.6112400.1519360.7625388.2830014.5533385.24
34782.3836774.1137693.7937882.8637796.6137458.6436960.0736349.9635509.9534758.83
34009.6933223.8632725.5731806.1730918.4330014.2429116.6228230.1227374.7126443.65
25593.9624806.0624073.5123305.3122495.3721680.8420848.2920012.0119166.9418318.49
17467.8816583.5215784.1714949.5714091.05 13256.412430.7911605.7310790.559973.045
 9165.248366.0887583.0346817.8696056.8185324.267
River Rch & RM=Bald Eagle,Loc Hav         ,82607.89
37658.271041.0211033.5471027.6431064.6551703.2512427.6792935.754 3480.544079.739
 4523.644901.3335311.4565721.3266099.5856569.6467051.4567445.2857940.7838459.048
 8894.239458.7799425.1479317.1959241.25911318.0618542.8924796.1929600.0733093.13
34567.8336648.6137626.4137850.1437788.7237468.9536980.6736378.0735541.0234794.89
34048.8633266.1232782.9331863.7430973.8930063.7729166.0128280.4927431.2626483.43
25648.8124863.6124137.8523370.9122564.3221751.24 20919.820085.3719240.6718393.61
17545.4916679.98 15866.915032.8814175.38 13341.212516.6711696.0510883.2610067.72
9259.5168464.8487686.1766926.4416167.8635441.495
River Rch & RM=Bald Eagle,Loc Hav         ,81849.41
37669.861044.0141036.1851029.5781041.6551447.626 2079.812520.1182968.6923418.816
3853.0214272.4624673.4665068.0685464.1135863.3686267.3686677.0447092.2257514.466
7944.131 8379.358360.4438319.4378259.10410446.0517873.2124312.1129261.64 32859.3
34394.6236548.79 37572.537826.6837781.7637476.1436997.0436401.1235565.5234823.82
34080.5433299.9832830.0531910.7531017.5430101.77 29205.828319.6727477.4926508.18
25692.3624909.5824190.5423423.6322620.2821808.5120979.2520144.1619299.9118454.51
17609.1916768.7415935.1515100.4214244.5713410.7512586.3911771.0710958.8810144.67
9334.8548544.9247768.9377014.6616257.4125535.602
River Rch & RM=Bald Eagle,Loc Hav         ,81084.18
37863.711044.0141036.1851029.5781041.6551447.626 2079.812520.1182968.6923418.815
3853.0214272.4614673.4655068.0685464.1125863.3686267.3686677.0447092.2257514.466
 7944.13 8379.358360.4438319.4378259.10410446.05 17873.224312.1129261.64 32859.3
34394.6236548.79 37572.537826.6837781.7637476.1436997.0436401.1235565.5234823.82
34080.5433299.9832830.0531910.7531017.5430101.77 29205.828319.6727477.4926508.18
25692.3624909.5824190.5423423.6322620.2821808.5120979.2520144.1619299.9118454.51
17609.1916768.7415935.1515100.4214244.5713410.7512586.3911771.0710958.8810144.67
9334.8548544.9247768.9377014.6616257.4125535.602
River Rch & RM=Bald Eagle,Loc Hav         ,80500.50
37862.131043.7991036.2861029.6531040.9921439.6642076.3872516.613  2965.63416.798
3850.8534270.3344671.5745066.2385462.315 5861.466266.009 6675.637090.7927513.005
7942.6568377.8668360.5448319.6178259.33810410.7817841.2724286.0929246.6432847.73
34392.6836509.0437557.2237829.0837787.6437486.5337015.8836422.5935587.8234850.02
34113.0433479.38 32830.8 31909.331019.4530110.26 29213.828328.3727477.4926532.57
25696.3924912.6724190.3923427.0522623.5421811.9720983.2820150.04 19305.318459.95
 17612.816746.7315936.9815103.0914248.3813415.1812592.3411772.8110961.6610148.58
9341.1998547.8617771.2517016.3326259.8915539.039
River Rch & RM=Bald Eagle,Loc Hav         ,79684.28
37859.561043.0231036.4991029.8161039.7931422.9192069.9682509.7982954.2053411.625
3844.0794263.254 4665.555060.3745456.6015855.7766258.1136667.2177081.8937503.625
7933.0638368.1738361.0948320.6918260.88510270.6917732.7824195.0429194.3432774.33
34385.0936493.2137550.4237829.1837789.3437490.7337022.4436430.1935596.01 34860.3
34122.2333477.85   3283931919.2131030.7530127.5429231.9628374.1727484.4426562.71
25708.4224921.79 24197.323435.7122630.4421824.72 20996.520164.0919319.6418473.46
   1762616741.4515949.5415114.7414262.6313430.73 12607.911785.4110975.0110163.63
9360.4838566.2067788.148 7030.386275.4935549.329
River Rch & RM=Bald Eagle,Loc Hav         ,78627.87
37858.69 1040.971036.9451030.1681037.503 1387.842048.989 2487.282927.0663402.661
3829.9414247.7534642.8235038.1865435.0925834.4566242.3426649.5837062.532 7482.85
 7911.31 8346.098362.129 8323.128264.3559945.51417440.9223954.5829044.3132534.27
34366.07 36449.337530.8537828.6137794.0237502.3137039.92 36450.835618.7234889.36
34146.5133478.9332863.4731956.2631067.0530172.1329278.8928542.9127509.3626644.19
25737.3424944.0324217.1323454.8822643.5621858.0421030.1720197.88 19355.418507.35
 17662.716770.1315982.4215145.4514298.2413467.7812643.2511817.0311010.8110200.63
9403.5328607.6667827.3317064.1316308.4315587.488
River Rch & RM=Bald Eagle,Loc Hav         ,76643.40
37854.891037.2561037.6441030.7961033.8791327.946  2002.42439.1592884.6043351.458
3775.655 4198.094583.6184986.3465384.5625783.8626191.5776595.7047005.649 7423.52
7851.8788286.2288364.0098329.3558273.2499190.28316626.5923265.4228686.6731792.06
34331.4736340.2937480.06 37820.937805.37 37530.937080.9636501.2435673.7834963.72
34203.68 33493.832917.9832072.4631176.8430289.5629390.7829015.5927582.5926139.95
25801.5524994.8824265.7523490.7522663.6121952.4621122.6620290.4519451.2518601.26
17765.5716909.5216077.9715239.6214399.8513567.2912737.9311911.42   1110410296.96
9508.3588716.5877936.6487170.471 6410.735678.526
River Rch & RM=Bald Eagle,Loc Hav         ,76002.96
37854.711035.9431037.8531030.9691033.1021312.5251989.2062428.284 2875.543332.276
3757.5534183.449 4571.864977.9335376.2195775.3176177.2956581.2386990.8137408.456
7837.1738271.5478364.3628330.8758275.381 9026.41 16444.623107.2828478.6631529.69
34324.1236306.2337463.5137817.2337808.5437539.8437093.6336516.66 35690.8 34987.5
 34221.233499.7932932.7832112.5631215.4530330.0929465.9229318.3127645.2425496.68
25851.5525038.9324312.9923540.8822667.4921974.0421143.6620311.8319472.8818622.87
17788.4216940.0216100.3615262.1514423.63 13590.312760.2811934.1511124.28 10318.4
9532.2918742.9267963.7497197.9646438.4535694.115
River Rch & RM=Bald Eagle,Loc Hav         ,75917.82
37851.591035.6881037.8871030.9941032.9741310.0571987.2462426.8472874.3793331.051
3756.3494182.5664571.1894977.5475375.826 5774.916176.867 6580.816990.3737408.023
7836.7348271.1178364.3658330.9198275.4449022.04916440.5923104.5428465.5531507.15
34320.5336302.8237461.7537816.8337808.7737540.5937094.73   3651835692.4134990.19
34223.5933501.2532935.4532115.9331218.86 30333.729471.6529332.4227649.5825476.89
25853.62 25040.824315.05 23543.222667.6921974.4121144.0320312.2119473.2618623.24
17788.8716940.5616100.8615262.6614424.1513590.8112760.7811934.6711124.77 10318.9
 9532.988743.7057964.5547198.7736439.2755694.879
River Rch & RM=Bald Eagle,Loc Hav         ,75616.14
37851.361034.9421037.969 1031.071032.6491303.2371981.6652423.101 2870.513326.967
3752.1314179.6364569.0944973.6575372.0925771.1416172.9296576.9566986.4617404.048
7832.8398267.3138364.3848331.3188275.9918985.59816392.7123068.7128369.1531405.17
34294.0236287.6537453.9437814.9237809.6437543.5337099.1336523.4835699.0635004.54
34237.3133510.9432952.2132132.3431235.4930350.5429488.7929394.8227674.6325518.47
25858.4925045.1724319.6223547.7922670.0821979.1621148.9120317.21 19478.318628.32
17794.1616947.0416106.5715268.4814430.0713596.6412766.4611940.5311130.2710324.62
9538.9518750.4517971.6187205.7536446.5615701.875
River Rch & RM=Bald Eagle,Loc Hav         ,74650.60
37845.531032.5231038.2081031.3081031.8661284.1531966.4312406.1212851.5563306.523
  3732.84169.3954556.8494953.2765352.0435750.5926151.2346556.0546965.2257382.796
7812.4428247.354 8363.838333.3348278.9798819.85116139.2222877.9328235.04 31265.4
34248.4936240.5237429.2437808.84 37811.937552.1837112.0436540.0235718.9535026.43
34258.53 33526.732976.8732157.1631260.5330375.4329512.8929450.4327703.06 25747.9
25883.0825067.7324342.8123571.3822685.3822003.9121174.5220343.9919504.8818655.35
17821.3416978.9916135.5715298.4714460.4213627.1312796.7711971.8211160.2310355.33
  9568.48784.6138008.6557243.0496486.1355740.242
River Rch & RM=Bald Eagle,Loc Hav         ,74207.96
37844.93 1031.061038.3461031.4341031.4861274.3831958.3272394.3262839.5713293.453
3720.6294164.2774547.7264943.3115341.9345739.8066139.5156544.9636954.0367371.709
 7801.998237.2788363.2858334.1968280.327 8751.5316014.9322784.7928171.4331206.73
34225.5636218.36 37417.437805.7937812.8537555.8437117.6436547.3835728.0235035.89
34268.0833534.32 32987.732168.13 31271.930386.7829523.91 29455.327716.6825879.94
25894.3525078.3724353.4723582.3422694.9322015.5521186.7820356.8719517.73 18668.5
17834.3616993.1916149.28 15312.914474.7913641.9512811.6311987.4811175.4910370.84
9583.0438801.3388027.2927262.0716506.6495760.309
River Rch & RM=Bald Eagle,Loc Hav         ,73504.24
37842.731028.2811038.5751031.6521030.8891258.8281944.8592372.8422816.8443268.808
3698.4814150.2294530.0894923.2645321.1895717.4946115.3426522.8466932.022 7350.01
7782.3458218.874 8361.98 8335.558282.7078646.91115769.2722595.7528037.4831094.85
34177.2736173.6437390.0137798.8437814.8237563.9337129.9236563.2935746.2835054.37
34287.0333550.0833009.0732189.97   3129530409.9629546.3929440.1827744.1426109.05
25917.3725099.3124374.2723604.0622716.3322038.5621211.3320382.3219543.5318694.99
17860.5117020.7316176.6415340.9214502.4913670.7812840.4812018.9611206.67 10402.5
9613.8728833.3448061.5027297.6346546.4165800.462
River Rch & RM=Bald Eagle,Loc Hav         ,72303.68
37840.521023.2971038.9261032.0531030.055 1227.981916.8662322.8912764.0183213.195
 3651.584112.9414492.379 4879.325275.4735668.7846063.4986478.0316888.5977307.935
7746.2568183.1328357.8258338.1048287.5388493.67715294.23 22215.127765.4930886.03
 34068.1 36076.237330.6737784.5237818.3237580.0237155.3936596.2835785.1635092.75
34327.2333585.1133054.5732232.6531340.9630456.1929590.7629369.2127799.1426466.12
25963.0825141.7224415.6623647.5522764.3722083.2121259.33   2043319594.4518747.93
17913.3217075.3716231.8615396.2814557.6213725.7712896.4312080.5211269.8110466.55
9679.4818899.5928128.0537363.607 6623.845882.723
River Rch & RM=Bald Eagle,Loc Hav         ,71400.81
37839.941020.2881039.0991032.2791029.6631208.6021898.8962291.4892731.3053179.694
3625.1594079.2724460.1924843.5235239.1735631.3376025.2856446.8356859.8147280.468
7719.6038155.6188353.4878339.9198290.7998410.66314929.9121929.9627565.06 30747.1
33974.8835994.9637284.9737773.4537820.7937591.4737174.0736620.7935816.6135123.23
 34359.8 33614.233091.2132267.1231378.2430489.1229622.48 29300.227839.4826652.51
25996.0925173.87 24446.923680.2922803.7422116.0621295.7220470.31 19631.918787.56
17952.8317116.2916273.73 15438.714599.8713767.12 12939.412123.7311315.2610513.05
 9729.228950.8838178.921 7412.346674.7035940.069
River Rch & RM=Bald Eagle,Loc Hav         ,70651.52
37839.081018.1891039.2071032.4571029.4531197.0421888.0422270.097 2709.753158.424
3610.6644043.9014429.5514812.2145208.5815600.6985996.223 6424.456836.3557257.736
7694.9618130.5618348.5938341.1178293.762  8358.914600.7921674.7227389.0930626.32
33889.6335922.4737243.6737764.1537822.6837601.6137189.9436641.5535843.8635149.21
34388.1333640.0333122.68 32299.531413.3330520.2729652.8529236.4527874.2426771.63
26024.2525201.9924474.0623708.8822840.1222145.3521328.5220503.2119665.1118820.22
17985.51 17150.116309.3215474.7514636.1213803.4512977.8512160.8911351.9510550.88
9771.7658995.1578223.7587457.1456716.4465980.892
River Rch & RM=Bald Eagle,Loc Hav         ,69567.33
 37834.7 1015.161039.3251032.734 1029.221179.6091871.9682238.7512678.492 3128.08
3569.9963992.3744385.6534769.4585167.4795559.7525960.5456386.8136795.8037218.469
7654.1618089.2078338.6958342.4018298.6048306.56314071.2521260.1127112.3830433.59
 33742.7 35802.6   3717437750.1837825.47 37617.837214.33   3667435887.2435188.92
34433.9833683.0533172.8632351.6931470.2530576.8429707.7729149.7527937.1626903.04
26067.3625245.7324516.5423752.9422898.9522190.9121379.8420555.0319717.6218870.57
18036.8817200.3116363.6615529.8114691.7713859.9113039.0612222.7211410.86 10611.8
9838.5499064.0698294.3727530.5256787.8586048.156
River Rch & RM=Bald Eagle,Loc Hav         ,68604.09
37833.771012.4171039.3921033.0131029.0741164.7761838.9712210.5662650.4773101.651
3513.0313947.9084347.0694733.8325133.2455525.6175923.823 6342.556754.2427178.359
7612.3438047.2158326.895 8343.28 8302.928280.82513536.4520872.0826860.9830287.76
33611.0335698.0537111.9837738.5837827.3237630.2537234.6436700.84 35923.535220.43
34472.86 33720.433214.8732396.2131519.2930625.8229754.9129103.6427995.1226984.02
 26105.125285.2924554.2923792.4222952.4522231.2221426.63 20601.919765.2518918.55
18086.1917248.2816414.8215581.6814744.32 13913.313099.6312284.0711471.1810675.52
9902.667  9129.78363.1957604.2746860.315 6126.08
River Rch & RM=Bald Eagle,Loc Hav         ,67326.78
37833.321008.8021039.4071033.4491028.9381145.7311792.7962171.2162612.4693066.828
3459.9393876.4284285.2314682.218 5083.865475.759 5869.466285.0966699.9027126.637
7558.8317993.6598310.512  8344.18307.8268264.50512891.6320433.9926585.4330158.45
33479.4335594.7737049.7837728.6337828.3637641.2337253.2736725.7135957.0935248.53
34509.7133756.7433254.0532439.2331566.9630673.6329800.8729082.0928050.6627056.59
26145.31 25328.7 24594.923835.17 23009.622274.4921478.5920654.3319818.0718971.89
18140.4517303.0616472.3415639.5214803.9313973.6113171.78 12357.111543.7910752.28
9979.3489207.6018447.1937698.069 6952.876225.849
River Rch & RM=Bald Eagle,Loc Hav         ,66070.17
37830.521005.7681039.3751033.8241028.8641127.0951768.7262146.9642582.1453043.284
3440.1643827.5474243.572 4645.155048.4425440.0065839.3276252.1736666.5627096.245
7527.6937962.6378294.8498343.8638311.5858260.45812413.0820031.0726317.3730041.85
33348.0535488.3236984.78 37720.837828.5537650.9537269.9636748.2435987.1435273.15
34545.9433793.5833291.4532481.0131612.8330719.6329845.7329086.08 28102.727112.88
 26182.625370.2924633.7323874.9323061.7922315.7821523.7920700.0419864.5319017.85
18186.29 17349.216522.8315689.9614858.7514029.7513223.9112409.9611597.1810806.62
10037.25 9265.49 8514.727752.5737006.7516282.813
River Rch & RM=Bald Eagle,Loc Hav         ,64908.02
37400.881003.7481039.3251034.1211028.8851112.2041742.9942131.8682559.552 3021.51
3421.8853809.593 4227.634627.0475031.2115422.818 5814.216224.3456638.7497074.009
7505.9547940.8298279.9288342.8758314.6928260.94711842.0119514.9725966.8429894.83
33182.5535345.2536896.9137712.9837827.7937661.84   3728936774.0936022.1135301.89
34592.3333842.1933337.7332532.4831669.53 30776.8 29901.229108.0328165.13 27174.8
26228.1825424.0124682.9223926.0323123.24 22366.621576.3720753.2319918.2919071.31
18239.7117404.4416585.8715752.7814923.6814096.2413280.5712467.7611656.4710865.82
10109.329339.2018570.6557790.7967044.7036330.254
River Rch & RM=Bald Eagle,Loc Hav         ,63812.99
37333.691002.3811039.2241034.3791028.9281102.0871720.1692119.0292546.0253003.441
3407.2853791.6564211.3934613.2965017.8955409.4775791.3236199.3576614.5977041.188
7478.1827912.7578264.6268341.1638317.1998263.06811328.5418954.5925567.4229718.92
33000.05 35184.2 36795.237706.4837826.3537672.5637307.1436798.9936055.0535329.79
34642.6633896.0233385.7132587.5831730.6330838.9129960.7229144.5428229.1327238.58
26278.6725482.8624736.9823982.0523185.8822421.0221634.2320812.0219977.2119130.62
18300.3917465.4816652.9815819.6314989.58 14163.6 13346.412534.7911729.3210940.62
10176.999410.0088619.339 7839.867093.4376372.385
River Rch & RM=Bald Eagle,Loc Hav         ,62746.41
37214.011001.3041039.0191034.6221028.9911092.8821697.2882106.3612532.9142988.252
3395.4083775.726 4197.154589.0444993.3565384.8845767.9766174.0916592.3457006.267
7437.8647871.8458238.2318336.5188319.6748267.61810907.2618351.1825121.1729500.31
32797.1235008.4736678.28 37700.537823.7537681.7237324.6136821.8236083.5135356.65
34695.8133954.1733435.5732646.9431796.5730906.4430026.38 29193.528293.8427307.35
26334.4425545.6424794.7324041.4923250.9622480.0921697.2920876.4820042.5119196.94
18368.2517534.5916722.7215889.4215060.8714236.5713417.6412607.9711803.4611019.93
10238.429476.8378687.0847911.064 7163.996413.303
River Rch & RM=Bald Eagle,Loc Hav         ,61896.89
37153.631000.6221038.8281034.8481029.0631085.8811676.3712096.4512518.1142971.396
3382.5863762.871 4186.034546.9134952.9385345.5555731.5726134.9816560.5386973.479
7393.2327826.2718206.8498330.114 8322.228273.178 10496.417833.9724744.9629303.28
32625.7634860.9736578.4337695.9637821.1837688.2937337.1136838.57 36102.735378.32
34739.5534002.1333476.0932696.3231851.0630962.5630081.1429236.9728344.4627364.25
26381.2125597.0724842.3224090.3523302.9122528.8921749.5520930.4720097.3319253.46
18425.2117594.1116780.82 15947.815122.1114299.5613478.8312672.2511865.4111084.79
10301.349546.7078758.4977988.8037241.563 6473.32
River Rch & RM=Bald Eagle,Loc Hav         ,60901.09
37091.271000.0721038.5071035.1091029.1681078.6291651.4432085.7852500.775  2952.6
3368.8753749.1114166.5764503.9234912.7625307.1065696.6836097.703 6513.566925.956
 7342.977776.0328171.5978322.1738324.8138279.29510108.9817262.9124309.7929072.17
32428.1634691.9636464.2237691.3437818.2737694.6837349.7436855.0136119.6235402.49
34789.3934056.2133520.8832752.6231912.8931026.4630142.4629286.3528396.1827427.87
26435.0525655.2624895.8624145.6823360.9822580.8321805.3920988.3820156.4519315.06
 18487.717658.05 16843.516010.8415183.67 14363.213540.9412738.9911934.9811155.79
 10370.5 9616.538830.4078071.3257326.2096559.542
River Rch & RM=Bald Eagle,Loc Hav         ,59795.28
37051.31 999.6971037.8911035.3881029.3621071.1561623.5942071.4372483.0642935.803
3353.2483733.6324143.4494484.8854894.6485289.8595672.0096071.6246470.0286883.229
7304.9517739.4118145.2918315.7968326.1768283.4769793.59716713.21 23896.728851.14
 32241.134534.42   36355 37686.337815.02 37699.137359.3836867.09 36129.4   35425
34835.3134106.3133561.8532804.6831970.38 31086.430199.4229332.5628436.4527486.47
26485.0125708.8824945.3524197.1823415.18 22627.821855.7821040.5920210.2119370.78
18544.51 17716.616901.7516069.6115238.33 14419.913597.0212798.6711999.1911223.12
10437.389678.695 8895.44 8129.577388.152 6635.51
River Rch & RM=Bald Eagle,Loc Hav         ,58836.23
37770.54999.52951037.0791035.6631029.5651064.8711597.8952057.4222466.5042919.653
3337.3633718.0954128.3674473.2584883.5945279.3395654.0426052.682 6451.336864.729
7289.8247724.7268134.4138312.931 8326.638285.0399636.646 16459.523713.6728749.96
32157.11 34464.736304.9637631.5537786.4637709.3837393.7436928.1836240.6435435.32
34855.3434128.3633579.84 32827.531995.6131112.9630224.38   2935328448.0227512.36
26506.8825731.8824967.1524219.59 23438.822649.3321878.7821064.49 20234.919396.02
18569.5417742.6216927.9316096.2115264.6114447.3313624.2312826.7912029.6711255.88
10470.549711.3998930.0958152.6227413.213 6667.15
River Rch & RM=Bald Eagle,Loc Hav         ,58708.54
37757.05999.51591036.9471035.7031029.5941064.0671594.1262055.5652464.339 2917.66
3335.6873716.4574126.7984472.0824882.448 5278.255652.9666051.5356450.2066863.618
7288.8857723.8048133.7198312.7248326.6538285.1379630.59716449.01 23706.928746.17
32140.6134453.1636297.1337626.6637784.7937709.85 37396.336932.9536248.8235436.98
34858.4734131.9433582.7232831.3432000.0631117.9230229.8529358.8328459.6227513.28
26507.6725732.7124967.9424220.3923439.65 22650.121879.6221065.3720235.8819397.03
18570.5417743.6916928.9816097.2915265.6914448.4713625.3612827.9512030.9811257.27
10471.959712.7828931.5668154.0677414.7986669.004
River Rch & RM=Bald Eagle,Loc Hav         ,58091.91
37749.45999.47631036.3321035.9061029.7591060.5891574.8732046.2112453.4582901.972
3322.6023703.8174114.9394457.2844868.7825265.4285640.3366038.2186437.0186850.613
7275.6047711.2778124.3348309.954 8326.798286.3489552.38816293.8823600.7328688.84
31967.1534326.7536210.9237594.6437775.3237711.2337410.4336960.2136290.4635455.32
34892.8934171.09 33614.232873.3932048.6531170.0630285.1529418.2128583.2127527.07
 26519.925745.5124979.8724232.8823453.0122662.2321892.5521079.2120250.9419412.55
18585.52 17759.316944.54   1611315281.3714465.1113641.9312845.1712050.7511275.56
10490.519731.0728950.9668173.1867436.1036690.107
River Rch & RM=Bald Eagle,Loc Hav         ,57700.27
37741.57999.46721036.0121035.9891029.8291058.9281563.7142040.9032447.3612888.143
3311.2213693.0044104.9564442.988 4855.82 5253.32  5628.46025.7256424.773  6838.5
7260.5027697.422 8113.968306.7378327.0678287.818 9469.4616117.8823476.0528621.48
31916.8634288.3336183.6737583.3237768.5537711.9337414.8236968.3936303.0735461.34
34903.4434182.9333623.5432885.9732062.9231185.1630300.4929433.4728605.19 27543.8
26534.2125760.4424993.9924247.54 23468.422676.4621907.7721095.4620268.5519430.83
18603.4817776.9416962.0516130.8515298.9414483.8213660.5512864.56 12073.711295.45
10510.839750.9968972.0748194.0237459.6916709.516
River Rch & RM=Bald Eagle,Loc Hav         ,57250.60
37727.38999.4672 1035.491036.1021029.9411056.7041547.5112033.4792438.9642874.148
3299.7923682.2474095.2764429.5084843.9455242.3065617.4946014.2856413.6186827.587
7247.0817682.8248103.0418303.264 8327.328289.4259386.61315922.7623333.6428544.45
31857.7434243.6236151.6437569.1137760.5837712.5137419.6536977.9336317.5635468.54
34915.5134196.7433634.5632900.7732079.4731202.7730318.2729451.21 28629.527562.95
 26550.525777.2525010.1524264.2623485.7522692.4621925.0621113.92 20288.8 19450.7
18623.3817796.24 16981.216150.3615318.1914504.3413681.0212886.0212096.8711316.11
10531.929771.7778994.0918215.733 7484.776726.786
River Rch & RM=Bald Eagle,Loc Hav         ,56775.92
37709.44999.46951034.8861036.2521030.0731054.3421529.5522025.5982430.1492864.516
3291.9643674.9134088.9094421.7414833.8715233.0425608.3196004.6776404.199 6818.54
7239.652 7669.118092.717 8299.918327.2338290.8139317.19115741.1523201.0228473.06
31803.3934203.2236122.1437554.9637752.9537712.6137423.4636986.3936330.2935475.32
 34926.334209.1133644.6832914.0832094.5431218.9330334.6329467.2228650.6927580.01
26565.63 25792.625025.0124279.5823501.8322707.0421940.8121130.9520306.8519468.09
18640.6117813.7416998.6416167.8715335.7714523.2413700.02 12906.412115.0911334.54
10550.549790.3279013.7628235.2887508.5946740.627
River Rch & RM=Bald Eagle,Loc Hav         ,56243.79
 37689.3999.47281034.2941036.3871030.2071052.4011513.3682017.1632421.0392847.594
3278.8713663.0564079.2754413.6214818.5265219.2035594.6085990.2356390.3696805.261
7229.1637654.073 8078.448294.7848327.1988292.5639232.02115509.7823034.6728384.33
31738.7534154.1836085.9537535.5937742.6337712.02 37427.336996.6536345.2335483.77
34938.9834223.7433656.5932930.0232112.5631237.7430353.9229485.9228676.1427600.94
26584.5825811.44 25043.424298.6723521.6222725.1821960.4221151.5220327.7719489.62
 18662.117835.45 17020.216189.6415357.4614547.0713724.0612930.78 12139.211358.99
 10575.49814.9629039.7888261.3747534.7466759.909
River Rch & RM=Bald Eagle,Loc Hav         ,55700.55
 37667.9999.48961033.5041036.5051030.3731050.3541494.6992006.581 2409.96 2828.94
3258.6643645.0284065.2664401.6614794.8645198.3745574.1685968.7426369.864 6785.84
7214.3127639.3298060.5788288.273 8327.078294.5029136.828 15227.722839.8828273.58
31658.33 34092.336040.1337508.5137728.6637710.3737431.47 37009.6 36363.5 35494.8
34954.7234241.9833671.3432950.3832135.2431260.3730377.4429508.9428707.1827626.95
26608.3225834.4225066.1124322.6623546.1122747.9121983.0721175.5220352.3719515.08
18687.4217860.8817045.4316215.2415383.0114575.7613753.1312957.6312168.5211388.33
10605.589844.9369071.4418292.7677560.578 6786.84
River Rch & RM=Bald Eagle,Loc Hav         ,54696.51
37596.26999.50811031.4231036.7191030.7371046.2861454.6841984.7222388.5492808.834
 3230.063620.1424047.5784385.9934763.6145157.3465534.2255927.4936330.9036749.628
7189.0957614.2938033.0448278.1148326.5688297.5478963.93814666.5122443.7128039.22
31490.3533969.39 35944.337443.7837695.5837704.1937437.6437035.3636399.0635518.88
34986.1634278.48   33700 32990.232179.8931305.9730425.3929556.1828769.5727681.65
26659.2425882.2625114.9824373.5123596.14   2279422027.9121224.25 20402.619567.19
18739.5217912.72   1709716267.45 15434.814630.6413808.96 13011.312227.58 11448.1
10667.799906.2529136.8448357.5527604.5856832.326
River Rch & RM=Bald Eagle,Loc Hav         ,53922.53
37468.36999.50481029.9961036.8571030.9741043.9811429.8681971.5112376.3612789.943
3213.8073606.8084026.4684365.8834740.5465126.2785503.735 5896.716302.3796724.226
 7164.077589.5858010.0628268.3968325.5058299.7358842.779 14221.622106.8127843.16
31352.6133872.1635863.88   37382 37663.337696.0237439.3237055.5836425.3435539.41
35010.1634306.6833721.9733020.0432213.9931342.1130463.5929594.1428818.3427726.66
26702.2725921.2125156.6124417.1823636.7922830.8622065.2721263.8720443.87 19610.7
18783.0717956.1517139.9316311.2815478.47 14673.213852.7213054.8712275.8811497.82
10720.049958.3139192.4038413.2737646.7996876.854
River Rch & RM=Bald Eagle,Loc Hav         ,52879.19
37339.14999.49111028.689 1036.961031.182 1042.251406.631 1960.682345.2192750.875
3184.9733585.3173966.9484307.2894675.2895069.4225447.6825840.9166251.7296682.558
7114.3737541.4897963.9918248.1668322.5748303.396 8702.4213598.2921621.2827556.31
31153.9633730.8935743.1137281.4537609.8237680.5837437.4537084.0436459.7735570.14
35042.9134345.85 33753.533061.7732262.3831393.14 30517.629648.0128885.4727792.31
26765.67 25976.925218.9324483.7623697.4922885.5122119.3821319.6320501.6519672.74
18845.0318018.01   1720116374.6815541.7414734.4713916.39 13115.712341.75 11567.4
10794.4710034.169273.1218495.6277725.2786963.321
River Rch & RM=Bald Eagle,Loc Hav         ,51784.74
37306.28999.46121027.289 1037.041031.4031040.6931383.0781943.3372306.6262714.387
3159.503 3544.29 3902.174243.4314608.4195012.2245391.0275785.8656202.9776631.253
7059.9027488.7967912.7458226.5478318.9318306.302 8592.3113008.34 21134.7 27259.3
30950.06 33584.235612.3937165.4737547.67 37660.537430.9837112.0336491.57 35602.5
35074.1234384.3533784.9233103.3332310.2831443.89 30571.529702.5228951.9927860.63
26832.0726033.9525286.1124555.1723761.9922942.7322175.1321376.9120559.7419734.35
 18907.318079.74 17262.116437.9215605.3114795.8713981.0813176.9712404.5811633.17
10867.39 10109.29354.6378578.2487803.6647056.028
River Rch & RM=Bald Eagle,Loc Hav         ,50720.68
 37300.7999.40111025.8811037.0781031.6261039.2951360.8581914.0532279.1792687.204
3110.0193482.9693841.0824184.8164555.8024967.2645345.4725736.2716162.1566581.319
 7008.857438.7377864.0798207.4878314.8158308.4698522.21712530.7220705.3126981.77
30761.4633445.2935480.9137043.7137480.6237636.9837419.78 37136.736517.0335632.33
 35100.734417.9333812.8933140.3932352.2431488.9330620.4629753.3429012.8927924.99
26894.9626085.9425352.2524624.9623823.6722996.4122227.3821431.1520613.5319789.86
18962.7118133.7517316.2516494.2115662.1514849.7814039.74 13232.512459.5511687.08
10928.3410172.159424.5948648.0327868.3757140.737
River Rch & RM=Bald Eagle,Loc Hav         ,49715.77
37297.98999.31681024.0581037.0991031.9131037.7141333.5111875.6212244.0182652.656
3024.2073416.6313771.9544119.1014502.1294920.5835297.0355675.7766114.6656533.416
6960.6177391.0937817.4428190.0928310.8838310.2048473.80412120.4320316.6926716.17
30582.5933310.5735347.3436917.37 37410.237611.4637405.4137159.5936538.8335660.37
35124.6534448.3333839.18 33174.332390.5231530.61 30666.729801.9829069.95 27987.9
 26954.826134.8825418.0124694.3223883.8323047.9422277.93 21482.5   20665 19842.1
19013.2718182.1917365.2316545.7215713.99 14898.214093.6113284.0712509.7711734.32
10981.7810226.869486.3118709.4497923.2927219.584
River Rch & RM=Bald Eagle,Loc Hav         ,48965.94
37296.39999.24151022.4471037.1151032.1751036.4321309.7561850.6672221.8232631.174
2984.4533369.1773723.2624073.6024468.7044890.301 5264.94 5637.176076.3086495.841
6923.0197354.0037781.017 8177.428307.9338311.0268441.81511826.0720026.0226510.99
30445.5833205.6135242.1636816.6237354.2937590.3237392.6437176.5336554.6635681.81
35142.5734470.8333858.8633199.5732419.5831561.8530701.9429839.74 29113.528036.77
27000.5226171.6425469.4224748.0123930.7223087.7822316.7621522.2720704.8119881.75
19051.4518218.6117401.6416584.5415753.0914934.4914134.2613323.0912547.4711769.62
11020.7910267.449532.5528754.845 7962.827280.929
River Rch & RM=Bald Eagle,Loc Hav         ,48110.09
37286.67999.16731020.9711037.0961032.396 1035.381288.6131835.5712208.6942616.538
2973.5613340.4243694.3664046.9154422.7094854.2815229.373 5600.166037.3666459.897
6887.3297319.0637746.7198158.5038302.8018311.7728405.97711501.3819678.67 26264.1
30282.2733079.6335113.2536693.11 37285.937563.6437375.9237195.96   3657235706.62
35163.0534496.6733881.6133229.0232453.2531598.1530743.1929884.2329164.4928094.68
 27054.6 26214.3 25532.124813.6323988.0323136.62 22362.921570.1120752.4919928.72
19096.4418261.8117445.1416631.4515800.5214979.1914181.9513368.6612590.9311810.75
11065.7710314.779591.0548813.9578016.9097338.841
River Rch & RM=Bald Eagle,Loc Hav         ,47453.14
37274.86999.11461019.8871037.0291032.558 1034.741274.256 1826.762201.0732607.179
2967.287 3334.51 3688.614041.5334395.5284834.7835211.1425582.0116013.0236440.494
6868.1837300.5457728.5238143.1828298.4438311.9988384.354 11251.119409.4626071.56
30155.0332982.4735010.7536594.0737231.5737542.3437361.8837210.1436583.9535724.71
35177.7534515.4833898.3133250.7732478.2931624.8130773.5529917.0729202.4628138.78
27095.2926246.4925581.7624865.8724033.4123174.9622398.4921606.7820789.3219964.78
19131.2418294.9417479.6616668.1615838.5115015.1814217.8313403.2712623.0711840.83
11101.2410353.049629.8028854.8428057.5297369.641
River Rch & RM=Bald Eagle,Loc Hav         ,46722.59
37268.49999.0431 1018.441036.8721032.785 1034.031256.1211814.1312190.3262595.906
2960.5623326.4833681.1854034.4754386.3124826.7255203.4095574.4655995.9136422.487
6850.3137283.3327711.611  8129.88294.0878311.8268370.57411035.3119102.8725809.12
29963.61 32842.834862.1136446.9537152.6837511.3137340.0637229.1236599.1535748.91
35196.9334540.8633921.09 33279.832512.2931660.3630813.8329962.0329253.9228199.67
27151.2726290.4325654.3824942.9824092.4823223.8322444.1121655.2920838.1820013.18
19178.5418340.4817519.3116709.47 15882.415057.0314258.8113442.8512660.55   11876
11131.3610387.379659.2988886.7838090.5467398.312
River Rch & RM=Bald Eagle,Loc Hav         ,46310.48
37265.95999.00381017.5241036.7351032.9161033.6531245.2421805.3532182.9812588.441
2956.5523317.0553672.9574026.5674376.6624817.6685194.6375566.1265989.0426411.421
6839.2097272.6417701.0268120.8348290.8598311.4258363.54510937.8618937.0525662.34
29855.87 32766.634780.6436366.2737110.2537494.3837327.8237239.0436606.8735761.54
35206.7734554.1333933.2533294.8632529.7931679.1230835.0929985.8829281.02 28232.1
27181.0526313.8725694.3324985.8824124.2123249.9522468.6921681.5720865.0920040.17
19204.8118366.2817540.5416731.1315906.0115080.0314281.2113464.5312681.5311896.07
11145.6710403.759677.8618906.8488111.177 7416.36
River Rch & RM=Bald Eagle,Loc Hav         ,45805.37
37247.11998.97381016.4181036.5471033.0811033.2471232.6561793.5032173.1242578.616
2947.7723302.0793660.2234014.2664362.0044803.5635180.9645553.2245973.9286396.255
6824.0077258.1397686.4138108.4048286.0138310.5558355.08810810.8818752.6625515.86
29757.8232698.9134706.9836294.1937072.9537479.2837316.5237247.3336613.0535772.12
35215.02 34565.233943.5333307.85 32544.631695.0530853.72 30006.829304.6128260.56
27207.2426334.43 25730.525024.7624155.5223275.4422492.8221707.03 20891.420066.41
19230.9118391.82 17564.516755.0415932.1915105.6714306.0113488.8812705.0811918.54
11166.6210425.649702.9748934.105 8139.45 7441.23
River Rch & RM=Bald Eagle,Loc Hav         ,45233.89
37242.37998.93311015.3511036.3341033.2351032.8671220.485 1782.152163.6542569.291
2934.6643288.2113648.8934003.2864349.3094790.7485168.4865541.5335951.1416379.005
 6806.547241.7777670.1868094.1018279.8658309.0928347.07710678.69 18530.725337.47
 29639.232617.9634616.9636206.6937028.1437461.2937302.9237256.8536619.7535784.23
35224.5634577.8833955.3933322.9332561.8431713.5730875.3330031.5629332.3628294.56
27237.7726358.2525773.9425071.2424193.3523305.8222521.2721737.3820922.6220097.62
19262.3518422.5317593.3316783.6215963.2815136.17 14335.613518.2612733.39 11945.5
11191.8610451.789730.7928964.5648171.0497469.148
River Rch & RM=Bald Eagle,Loc Hav         ,44529.29
 37237.8998.88261014.1851036.054  1033.4 1032.481207.1431771.111 2154.162560.231
2914.3663266.9053633.2653987.9894332.4364772.3265150.2965524.9415925.2496354.293
6781.2477218.991 7647.938073.2278270.3368306.6758337.96810513.8218217.67 25089.4
29476.3432507.7434491.7736086.61 36967.337436.95 37284.137269.35 36628.335800.15
35237.05 34594.433971.2933342.7132584.3631738.1230903.7330064.3729369.5228340.55
27277.9426389.6925832.9825134.0724244.8823347.3222559.5421778.6620965.1720140.45
19305.3718464.7317633.2316823.5416005.8315178.2814376.9113559.1412773.0211983.78
11227.5710491.33 9769.049005.9798214.4177508.005
River Rch & RM=Bald Eagle,Loc Hav         ,43919.30
37209.47998.85341013.0341035.7761033.5641032.1681194.3581752.6282137.5382545.059
2896.5213240.9413616.0523970.7244313.9814751.1345129.0035506.1435905.485 6328.73
6755.6967196.9767626.0158052.3498260.215 8303.868330.84310370.21 17913.624849.94
29320.6832403.9434371.4335972.4736910.1637413.5637265.5837280.7336635.8235814.75
35248.3134609.62 33985.833360.7232605.2131760.7130929.8130095.1829404.1928383.57
27315.6926418.8525888.8925193.5524293.9423386.5522595.9921817.5621005.3920181.07
19346.0418504.9317671.67 16862.116046.1615218.1914416.0613598.0412811.1112021.11
11262.3710529.249805.4289045.2738256.0967546.024
River Rch & RM=Bald Eagle,Loc Hav         ,42895.87
37194.75998.81431010.9671035.1471033.8491031.6621171.4131698.9342091.4532506.178
2875.1383203.477 3574.033930.5244273.377  4702.75080.9695465.4775863.6916283.219
6711.1537150.5847580.6478008.2288237.6678296.5568319.77710109.6917291.5724369.03
29010.5532200.4334131.1135746.4736798.7537367.1337228.9337301.5436649.2135842.23
 35269.334638.6434013.8433395.21 32645.131803.77 30979.930155.3229471.6228467.45
 27388.9 26475.525999.6225311.0424391.0323463.5222668.5721893.7721084.7520261.04
19426.57 18584.417748.1316939.6816126.24 15297.414493.6213675.79 12887.4 12096.2
11334.3610602.359876.6169123.2488339.4817623.031
River Rch & RM=Bald Eagle,Loc Hav         ,41806.43
37184.76998.81951009.4121034.497  1034.1 1031.361154.3151631.9912040.8392468.441
2823.8643142.8063501.0353866.6474213.5284630.6915011.3855402.7355801.9396226.574
6656.1517091.3737523.6227952.0528207.3898286.5048309.7649823.104 16542.8 23798.9
28647.7231963.91 33848.235481.7136668.6237313.2837185.2937324.4136663.4535873.12
35293.0134671.2734045.8533434.3732690.1631852.6631037.0630224.0529548.9928563.65
27472.1626540.8726129.3825448.3124503.9123552.9822753.1921982.5821176.9320354.72
19521.2418677.5117837.3617031.2916219.5115390.3514585.1713767.3712977.9212185.73
11421.2110689.499961.1129216.6738439.6027717.771
River Rch & RM=Bald Eagle,Loc Hav         ,40526.85
37115.57998.84911007.1561032.7071034.2641031.1521130.0321552.4841991.1632387.437
2717.6693030.529 3400.553783.2254129.9584532.2844918.3365316.2295720.6656153.979
6585.8387022.0267457.227 7886.868171.235 8273.928300.2299522.737   1569323146.68
28233.51 31693.9 33514.335171.5236517.9737250.8937132.1737350.1536678.9935908.01
35319.4734707.6934081.2933478.2232741.4631908.2431101.9530303.1129637.3628673.74
27567.8526616.13   2627825605.3224632.8323654.4622849.0622082.8321280.9920460.91
 19628.118782.7417938.7717135.2916323.5115495.3714688.0713870.0613079.91   12287
11519.7810787.2710056.179322.5158552.1597826.336
River Rch & RM=Bald Eagle,Loc Hav         ,39499.37
37102.86998.88661005.1761030.7431034.3031031.1141108.6421502.551 1938.432299.349
2635.777 2951.57 3336.673719.9624064.1454456.1944848.5265253.3375662.9616102.563
6535.7916971.9527409.3687839.9278144.7338264.3138294.0029319.242 15084.822677.57
27933.7431498.99 33265.834941.98 36407.737204.2937092.2137368.33 36689.535932.82
35338.3134734.0734107.1433509.9632777.8831948.0731148.4130360.4629701.4828754.18
27636.7826671.14 26387.125719.0224726.4123727.4122918.2122155.3321356.6120536.87
19704.9518858.5318011.4517210.5416398.6215570.1514761.6213943.0713152.4312359.02
11590.7310856.7910123.149397.6778632.008 7903.48
River Rch & RM=Bald Eagle,Loc Hav         ,38446.87
37033.36998.93761003.9931029.2171034.2781031.182 1095.461468.6531882.4032239.946
2583.0222902.941  3286.13665.7044011.2184395.6084794.3975204.9025619.3566059.119
6493.3916930.9197370.175 7800.958122.3948256.2128289.3079158.72814592.9722299.38
27690.4631341.8533059.8834753.0236319.0437165.9337059.0937381.9936696.7635951.43
35352.8234754.8434127.6333535.1832806.3931980.0731184.9730406.3429753.1828818.85
27690.8126716.12 26477.725811.4524803.1523786.4622974.6722215.4621418.9420598.96
19767.6618920.2818070.4817272.0716460.7915631.4214821.41 14002.513211.1712417.82
11648.33 10914.710178.439458.4178697.0577966.511
River Rch & RM=Bald Eagle,Loc Hav         ,37962.54
37026.08998.95811003.6161028.595 1034.241031.2161091.158 1456.531870.1472219.437
2565.6152888.0883263.5883645.9473992.0464373.8884775.7495188.2175604.8696043.505
6478.4256916.733 7356.617787.3958114.6198253.2858287.8379105.267 14423.622167.73
27604.6831286.6732984.2134684.0436287.8137152.3437046.7437386.4636698.8535957.41
35357.5834761.7634134.6233543.8332816.41 31991.531197.4430422.5429771.3128841.47
27709.5626732.4926510.2925844.4224830.6823807.3222994.7622236.9721441.1520620.95
19789.6718941.8618091.3117293.8516482.76 15653.314842.1414023.28 13231.7 12438.4
 11668.510934.95 10197.99479.1268719.5167988.233
River Rch & RM=Bald Eagle,Loc Hav         ,37385.23
37019.53 998.9791003.1511027.727 1034.151031.2721086.1521441.3661857.583  2196.5
2546.5322872.8063241.7853626.8073973.6674353.2324758.5495172.8425589.2846028.086
6463.7556903.1017343.4367774.3428107.0378250.3448286.4659055.11314259.0822037.62
27518.6131231.5132903.4134610.5136253.8737137.2737032.6737390.6636700.4835963.46
35362.4134769.0134141.91 33552.832826.8232003.5631210.4930439.1429789.8728864.58
27728.56   26750 26544.325877.9524858.52 23828.223015.0822258.7521463.7120643.23
 19811.618963.3518112.18 17315.8 16504.915675.3914862.3814043.5913251.9212458.52
11688.4910954.9810217.04 9499.028741.1558009.112
River Rch & RM=Bald Eagle,Loc Hav         ,36769.88
37011.88998.99841002.625 1026.651034.0091031.3421080.4971423.5911842.9242181.008
2533.729 2863.483229.3133615.8423963.1914341.5834749.0425164.3645579.4236018.348
6454.4946894.6487335.3047766.1918102.222 8248.428285.5449024.76514156.2421955.74
27463.7231196.5432847.0134399.1936186.24 37106.5 37003.337397.3636702.3235973.84
35370.9634782.5434156.0933569.56 32846.532027.6531236.3830474.6929838.9528927.51
27779.07 26807.126766.06 25899.824876.7923841.6323028.3422273.0521478.5220657.96
19825.9118977.1118125.8217330.0716519.2915689.8114875.2714056.5613264.7912471.33
11701.2110967.8310229.299511.3158754.5848022.061
River Rch & RM=Bald Eagle,Loc Hav         ,36663.76
35539.55998.99841002.625 1026.651034.0091031.3421080.4971423.5911842.9242181.008
2533.729 2863.483229.3133615.8423963.1914341.5834749.0425164.3645579.4236018.348
6454.4946894.6487335.3047766.1918102.222 8248.428285.5449024.76514156.2421955.74
27463.7231196.5432847.0134399.1936186.24 37106.5 37003.337397.3636702.3235973.84
35370.9634782.5434156.0933569.56 32846.532027.6531236.3830474.6929838.9528927.51
27779.07 26807.126766.06 25899.824876.7923841.6323028.3422273.0521478.5220657.96
19825.9118977.1118125.8217330.0716519.2915689.8114875.2714056.5613264.7912471.33
11701.2110967.8310229.299511.3158754.5848022.061
River Rch & RM=Bald Eagle,Loc Hav         ,36339.56
35547.61999.00331002.4591026.2931033.9621031.3631078.6561417.5571837.255 2175.12
2528.9332857.0133222.7423610.0583957.6214335.3964744.3845159.9485573.265 6012.37
6449.0836889.8747330.7997761.547 8099.248247.2388285.1549009.48614099.8221904.55
27437.5331176.7632828.53 34378.536159.4537084.3936987.2637351.4136680.44 35968.9
35373.1534791.4134169.0933586.1532867.7232053.2531273.6130481.8229846.4828936.19
27789.1726815.4826772.04 25909.724886.7423852.4423039.6522284.84 21490.3 20669.6
19837.3218987.6218136.2817341.1316530.1715699.2514883.9814065.1813273.1312479.39
11709.4810975.8610236.929517.7438762.2098029.666
River Rch & RM=Bald Eagle,Loc Hav         ,35648.50
35478.57999.00731002.1371025.5181033.8281031.4321075.1221405.1611821.8082159.621
2516.4672842.0363200.0983590.1363938.4084314.0114729.2945146.0565555.0845988.989
6428.6516872.3457313.9047744.3468088.0418242.7118283.521 8955.7813869.4421702.29
27329.9831093.26   3274534283.1336040.4336986.8136914.5637297.88 36651.5 35961.3
35375.0234802.1234185.1133606.3832892.94 32081.431305.9430513.0429878.6728972.54
27831.9726852.0926797.8325951.0224929.4223898.7923088.8522335.1321540.2820719.09
19885.6219032.5318181.2917389.8616574.8915739.6414920.8314102.0713308.6712514.12
11745.3711003.5910263.029540.8648790.5238057.673
River Rch & RM=Bald Eagle,Loc Hav         ,35072.37
35435.78998.99941001.8251024.6891033.6681031.5041071.6451392.3341807.3652145.599
2505.2942834.2253178.2413571.0743919.9394293.4484716.0585133.6895542.3585971.492
6410.5996856.9587298.6447728.8098077.6468238.1818282.0318911.77313663.9321529.36
27235.5831016.3432659.7134180.09 35918.136885.9536834.9137238.4836619.58 35951.5
35376.1934812.32 34200.933626.5832917.73 32110.1 31338.330545.3629909.5229006.74
27872.3826888.9626824.04 25989.824970.5923943.3923135.17 22382.721587.4720765.94
19931.1519074.7918224.8817435.3216616.0915778.3214955.9914137.58 13342.812547.54
11775.5911025.8810283.739560.5978816.1768082.841
River Rch & RM=Bald Eagle,Loc Hav         ,34098.93
35392.99998.95211001.2011022.6541033.2691031.7071063.9641362.925 1781.442104.185
2473.2342810.7883141.6933524.3513874.9744243.8184687.2485106.0485514.0365942.301
6371.6526821.6447262.8687691.9568051.9088226.703 8278.268817.68113288.4221138.62
27034.44 30829.632428.6233914.9135608.98 36632.436643.4237092.4136541.3735925.21
35377.0834833.9434236.2233671.6832973.1932174.8731411.5630619.9429980.7629086.19
 27965.826978.87 26888.926078.2925066.8524048.5223243.9622496.8621701.1720879.86
20042.6519177.0818333.4717542.5816717.1815872.82 15041.514225.5613427.9912630.35
11835.3911077.1810330.899604.1698877.7278142.916
River Rch & RM=Bald Eagle,Loc Hav         ,33498.68
35384.92998.92171000.8251021.3781033.0021031.8321059.4381345.3161768.3812079.084
2454.094 2796.753127.9123491.829 3843.744209.6864669.1535088.418 5495.915923.552
6350.7176791.3157231.628 7659.948028.7458216.3978275.0568741.69113022.7520829.19
26884.3830677.6932231.4733701.5235365.8736435.1836501.1436983.3836482.9735904.99
35377.1734848.6134261.5233703.16 33013.232221.7831463.68 30673.530033.6329145.79
28035.6727047.7226938.4626144.6225139.7524128.44 23329.222586.99   2179120970.35
20131.1419257.7618420.4117630.7116800.2715950.6915112.4914299.1213500.0712694.88
11886.2111120.0210369.359639.748 8930.968194.772
River Rch & RM=Bald Eagle,Loc Hav         ,32195.47
35352.79998.88451000.3821019.6981032.6011031.9731054.0411320.6391749.8052056.357
2420.7642777.2323109.3343449.708    38034165.1734619.5415041.4435458.3265884.055
6317.5946738.2337175.6897602.3657986.1258196.7618269.5178620.45612374.3420161.14
26552.1430275.8331687.7233170.0234785.7235976.7336174.7736729.0136347.3235856.31
35374.9934880.0934317.2433771.9433100.6132326.5831578.2630791.2330151.5429277.38
28188.3627203.63 27050.726290.3625301.9424308.53 23520.422791.51 21996.121177.14
20335.6319442.7618620.1117841.5517002.1716144.4515294.82 14476.413678.2412848.33
12024.3711235.0810475.769747.8469026.8628286.581
River Rch & RM=Bald Eagle,Loc Hav         ,30878.12
 35336.7998.85891000.047  1017.91032.1441032.1251049.9691295.5211713.8492025.346
2374.2292719.6283059.214 3399.923752.925 4108.134530.4714960.8515386.3985806.791
6257.4446688.886 7119.15 7541.787937.1888171.7398262.1388536.18911597.9719363.03
26135.1529650.15 30851.932450.7134045.3135405.2635773.1236416.1436182.0435794.77
35370.2234915.8134379.8633852.8933202.27 32447.731713.7930929.84 30292.429432.18
28367.7327391.6927187.6926460.17 25494.3 24524.3 23751.123040.4622247.9621434.63
20593.9919668.8618876.0218114.7117269.6416410.4815557.4814721.1913933.46   13077
12237.0511414.5610654.069914.425 9132.458384.711
River Rch & RM=Bald Eagle,Loc Hav         ,29563.77
35323.18998.8289999.68511015.8011031.609 1032.271046.2121270.1581663.9551984.365
2331.4772624.686 2988.12 3330.223679.3014025.3974429.9314870.8635279.5795694.121
6185.7196630.7267047.0967464.1357872.2738137.915 8251.668447.12710818.4818447.98
25588.4128776.7129752.5431570.1533175.5734745.4635309.1736061.5435994.1835723.36
35364.47 34954.134449.9733942.8633315.4632582.14 31863.4 31085.430450.2429604.98
28569.9827605.01 27345.726652.3525713.5124769.7824017.9423330.84 22540.521734.94
20898.34 19922.919186.22 18445.617596.0316741.3915896.1615046.2914259.5713374.42
12520.1311658.1310914.8110105.619268.2888517.582
River Rch & RM=Bald Eagle,Loc Hav         ,27226.40
 35314.6998.7967999.36021013.1991030.4041032.5311040.7561225.7791608.4031939.838
2284.2682527.155 2911.793257.2293605.3373944.9324332.1354781.2345163.5915574.842
6085.3026549.461 6965.347373.0157791.5848092.5018234.6588359.4569977.79516793.11
23706.6826696.3327518.8929896.1131568.1533544.0634467.8335421.1335653.7535591.97
   3535135020.3934576.6134100.7833514.4232823.14 32126.731363.8430730.6229914.87
28929.8227987.4827630.8826992.1926107.0925209.5524501.0823857.8323070.7822276.61
21450.4920341.2619765.0519060.7618207.3817370.4816561.0615721.22 14902.513988.03
13142.3812268.2311442.7810526.439642.5748730.358
River Rch & RM=Bald Eagle,Loc Hav         ,25960.70
35309.67998.8057999.24231011.9731029.6021032.6651038.256 1201.441587.6041922.543
2265.0852514.0142889.8653237.3773585.4413925.2494307.5474756.4215142.8845552.828
6042.0146515.2586928.1677329.8257748.9838063.7658218.9038334.8329732.87715532.67
21978.7925282.2926200.56 28953.230685.7232888.7434013.0735072.0235470.6235520.47
35342.2135055.84 34642.334183.8233619.4132953.4632267.5631513.7530881.2330081.34
29121.9828191.5427784.0327172.0426317.0225444.7624761.9824143.3923359.2222571.41
21751.3920551.3120085.3419402.38 18548.117725.3716946.3316128.3515288.2214371.46
13557.33 12725.611846.5510934.7510022.719023.254
River Rch & RM=Bald Eagle,Loc Hav         ,24843.25
35307.86998.8502999.11361010.6671028.8281032.7351036.6511182.4721567.4741905.821
2240.7772499.6462867.5563217.5293563.2083904.3874282.0964714.6055113.9455519.938
 5994.866477.823    68837280.9117682.8078018.7488191.5258306.4369464.89114368.21
20610.1524113.1125115.97   2818529947.26 32341.633612.9634763.9335309.6635456.69
35334.5135087.44 34699.834257.07 33711.633065.9132390.3331644.5331012.9830226.36
29291.4128362.0627912.3627322.4626491.5425640.6524978.6624382.9623592.28 22809.6
21995.3120733.1220344.5619669.0418813.6518003.8617250.9416433.1915576.79 14662.5
13879.4813067.4512197.3811305.7510364.649375.933
River Rch & RM=Bald Eagle,Loc Hav         ,24417.73
35311.18 998.869999.07621010.1751028.5371032.7581036.1521175.7231560.8741900.354
2232.5812493.6252858.0833209.0743554.8623896.8294273.058  4699.4 5097.645501.612
5969.2326457.6066864.3847261.4657657.1097996.8138178.324 8293.829349.48614012.92
20214.3923698.5924732.8727914.2929685.4132147.5433469.8234654.2535252.0435433.73
35331.92 35098.334720.3934283.5333745.0433105.5932434.0931691.0231059.6630278.23
29351.7428423.2227957.9527375.7626553.4625710.0525055.8724467.5923674.38 22893.8
22081.1620806.2520436.6219761.93 18906.418101.1217357.32 16529.515667.8914754.63
13981.8613164.4812298.1311415.1210465.679484.537
River Rch & RM=Bald Eagle,Loc Hav         ,23872.06
35304.51998.8726999.03781009.6951028.2581032.7841035.6981169.4161553.2181894.397
 2226.062488.0192849.3493201.1163547.1773889.7124264.6064690.9435083.2675485.769
5947.6126440.4286848.7127245.195 7641.627980.175 8168.498284.5139266.52513755.19
19916.3723390.4224460.3227289.4529244.4731822.3433307.9834530.5835186.4835407.79
   3532935110.3334743.6634312.8333783.0933151.0232483.8531743.9831113.29 30336.8
29419.5228524.5228034.2927464.5226656.2625826.4225184.8224610.0623858.4923085.69
22281.1121112.67 20502.419830.6218974.8718172.7317435.6316600.7515735.1214822.71
14057.4113237.0612373.94 11497.5 10538.89563.578
River Rch & RM=Bald Eagle,Loc Hav         ,23783.65
35307.33998.8749999.03221009.6451028.2261032.7881035.6521168.734 1552.091893.595
2225.2012487.5152848.5833200.3933546.4943889.0424263.8124690.1775082.5655484.996
5946.5896439.5626847.9177244.4097640.8827979.574 8168.128284.2199264.08713747.79
19908.9223386.2524459.0727146.9329196.3731787.0533284.3834512.4935176.9235403.99
 35328.635112.1434747.0934317.0733788.5433157.6532491.05 31751.731121.0530345.34
29429.3828535.4528042.6527474.2226667.4925839.1125198.9424625.61 23899.623128.72
22328.2221161.88 20502.719830.9318975.1818173.0517436.61 16601.815736.0914823.72
14058.9813238.8512375.8211499.5210540.979565.954
River Rch & RM=Bald Eagle,Loc Hav         ,23384.79
35306.96998.8807 999.0351009.3861028.0671032.7861035.431 1165.08 1545.981889.307
 2220.572482.8232841.6043193.8223540.3113883.0154256.7994678.3245072.1495473.578
5931.8026427.003 6836.517230.6437627.8317969.1198161.7958279.3159221.76113607.03
19725.7723242.3324324.09 26726.5 29003.631643.4133186.8934436.4935136.8235388.03
35326.9135119.4334761.0434335.05 33811.5 33185.232521.8531783.1431152.9630380.43
29470.2528579.9728076.2627513.4526713.1225890.4125255.3924687.6624020.6923255.33
 22463.821366.2320534.4419864.3919008.3418205.2517470.7916638.4915770.5214857.75
14097.3213282.5412414.5511541.27 10585.79610.289
River Rch & RM=Bald Eagle,Loc Hav         ,22982.97
35306.54998.9038999.02151008.8921027.7041032.7661035.0561158.1251535.2941882.161
2212.7542475.7822825.7163179.4393527.2553870.5344242.3334658.232 5052.615452.396
5904.5256404.1546815.8527207.4557604.9417950.7748150.5998270.6459148.70713363.46
19416.5522988.3124087.3726540.1628839.1931516.6133099.1334366.6935099.8435373.26
35325.4135126.1634774.1834351.6433832.5933210.5732549.8131811.3831181.72 30412.2
29507.2328619.1128106.0527547.7426753.5925935.8725303.5824740.6924074.7323311.47
 22523.621453.7520590.2519922.7619066.6318261.4917530.7316703.0515831.0714914.79
14161.9213356.0112482.4811615.1210664.949687.079
River Rch & RM=Bald Eagle,Loc Hav         ,22386.15
35306.04998.9292998.95361008.049 1027.041032.7671034.4921146.9751520.1511871.098
2200.5422467.5072803.9813160.5263510.487 3852.914221.9854636.4195030.4165428.654
5874.2716370.9826786.1217177.782 7575.577927.1488136.1628258.7489051.87913043.27
19060.6122675.8623805.2526320.5928644.9831367.7732996.0334286.4435057.37 35356.1
 35323.535134.1834789.5534370.7833856.7733239.6332581.8731844.5631215.58 30449.7
29550.5228664.8228141.0527588.0326800.7925988.9525360.2124803.5224138.6723377.48
22593.8221560.0520656.9219992.0819134.6718329.6717603.6816781.4915900.8914981.63
14237.64 13440.312568.0711708.2510763.939788.324
River Rch & RM=Bald Eagle,Loc Hav         ,21283.34
35301.63998.9103998.92471006.8781026.0481032.7461033.8591131.9411504.5721857.295
2185.1162457.1352783.825 3143.523495.9623835.2374201.9784615.0785010.3025407.543
5848.1186333.2296752.6177144.7627544.6257902.2558120.9258245.772 8948.8712708.11
18726.5622381.7123551.12 26130.727993.9230924.1632867.9534188.2735005.7135334.79
35320.7735143.8734807.6434393.6333885.8133274.7632621.2331886.1331257.7130497.23
29675.2628799.9328244.8227708.6126942.0226150.8925549.7424857.5624194.0623434.32
22654.2121655.9320716.9220054.6219194.2618392.4617670.7816853.63 15961.415045.51
 14309.913519.4112651.5911799.0210859.55 9894.76
River Rch & RM=Bald Eagle,Loc Hav         ,21199.93
35295.46998.9103998.92471006.8781026.0481032.7461033.8591131.9411504.5721857.295
2185.1162457.1352783.825 3143.523495.9623835.2374201.9784615.0785010.3025407.543
5848.1186333.2296752.6177144.7627544.6257902.2558120.9258245.7728948.86912708.11
18726.5622381.7123551.12 26130.727993.9230924.1632867.9534188.2735005.7135334.79
35320.7735143.8734807.6434393.6333885.8133274.7632621.2331886.1331257.7130497.23
29675.2628799.9328244.8227708.6126942.0226150.8925549.7424857.5624194.0623434.32
22654.2121655.9320716.9220054.6219194.2618392.4617670.7816853.63 15961.415045.51
 14309.913519.4112651.5911799.0210859.55 9894.76
River Rch & RM=Bald Eagle,Loc Hav         ,20127.30
35291.07998.8762998.90221005.8991025.162 1032.741033.3391119.9161494.0521848.023
2174.4892449.6242768.4413131.7183485.0273823.7094188.9034600.5114996.8665393.476
5830.8396316.6396737.8527130.4117531.3857891.1228113.9328240.4968911.43312587.66
18604.5122305.3323477.3826075.5427945.0430395.2532492.7334120.4234967.5235319.51
35318.4635149.6534819.6834409.3233905.5433298.27 32646.831913.2131285.0730616.08
29818.91 28955.5 28355.5 27825.827084.2426335.55 25563.524872.4124209.0723450.78
22670.43 21684.220734.21 20072.319212.4818410.3817687.49 16872.4 15982.915068.11
14336.5413549.09 12683.4 11833.110896.419935.018
River Rch & RM=Bald Eagle,Loc Hav         ,19036.24
35282.03998.8505998.91581005.1811024.3641032.6511033.0271110.7251482.6681838.538
2163.7442442.1852754.7573120.7013473.5153812.2254176.1954586.9554984.4255380.051
5814.6216300.5976723.6227116.8297519.1657880.3798107.0458235.6468880.08812482.03
18490.6722224.3723402.29 26014.727893.3530343.0432453.1634091.1734951.0135312.65
35317.22 35151.934824.4834415.8233913.6533307.8232657.2231924.4231296.2930628.38
29833.3428971.1228366.5527836.6227096.6726348.7725578.2824887.9624224.7523468.11
22687.4121711.3420751.7820089.6919230.3118427.8617703.9316889.8116002.6315089.46
14361.9513576.8412713.35 11865.110930.799972.737
River Rch & RM=Bald Eagle,Loc Hav         ,18200.10
35284.09998.7424998.88921004.5611023.455 1032.481032.8591103.1251462.5991825.316
 2150.112433.5972739.6033107.1863459.8033799.9524163.2464573.0534971.9245366.066
5798.6886283.9816709.0637103.1357507.1667869.6798099.5478230.5638850.64712374.01
18368.4422131.1323321.4825950.1627839.3530286.75 32410.534059.5234933.12 35305.2
35315.8835154.2334829.5534422.6533922.2533318.0532668.2431936.4631308.2430641.51
29848.7828987.7328378.4627848.2627109.7726362.5525593.9324904.1824241.0723486.09
22704.8521737.8720770.6320107.8919249.0118446.0417721.0216908.1116023.1515112.59
14388.9213606.6612746.14 11899.210967.5410012.59
River Rch & RM=Bald Eagle,Loc Hav         ,17549.23
35286.07998.6284998.85631003.9781022.5831032.2921032.7361096.3331440.9651812.341
2137.1452425.5152725.4593094.3983446.9023787.9734150.7894559.7054959.9995352.705
5782.5696267.0966694.3237089.4257494.1257858.1298091.5818225.1468820.12312257.47
   1823122026.5423233.5425882.0427782.9730227.8632365.9934026.2334914.38 35297.5
35314.4235156.6134834.7934429.7533931.1133328.8432679.7731949.01 31320.930655.26
29864.8929005.0828390.9427860.4727123.5926377.0825610.3824921.1924258.0723504.77
22723.2321765.4520790.9820127.4719269.3618465.9217739.5616928.2816045.8215138.14
14418.9613639.6612782.4411937.2711007.8410056.73
River Rch & RM=Bald Eagle,Loc Hav         ,16787.45
35279.67998.5255998.8354  1003.41021.6371032.0451032.6181089.4731418.6781798.997
2123.9112417.2672711.3593081.4533433.7493775.7414138.1064546.0944947.8295339.046
5765.9926249.0816678.574 7074.887480.1527845.7318083.4348219.4798788.93812140.75
18092.5421920.3223134.9725805.1927716.65 30157.832312.9433986.3734891.95 35288.2
35312.5435159.3834841.0834438.1233941.5933341.6132693.3531963.8231335.9630671.79
29883.8629025.7228405.9327874.7727139.7126394.0925629.7124941.0924277.9823526.74
22743.6721795.2820813.6720149.1819292.0418486.4717758.7916949.0916069.1415164.68
14449.24 13672.812818.8511975.7511048.3810101.71
River Rch & RM=Bald Eagle,Loc Hav         ,15407.88
35273.01998.3616998.78111002.6031020.258 1031.681032.4481080.2711387.0771778.837
2103.8082405.2812691.1583062.5283413.1953758.6064120.3914527.0184930.4845318.963
5743.9416224.096 6656.637051.7857460.2317827.7778071.3878211.2398746.50711983.54
17904.1221766.4722998.9425696.9627624.8530061.2932239.0633931.4534860.9735275.11
35309.7735163.1434849.5234449.4633955.7933358.7832711.4931983.9431356.2930695.07
29909.97   2905428426.6427894.0827161.4826417.0525655.9924968.4224305.4123556.97
22770.8321832.44 20845.320178.7919322.6718513.5217784.1316976.8716100.0915200.73
14489.6213718.2912868.6412028.2311105.6510163.73
River Rch & RM=Bald Eagle,Loc Hav         ,14814.34
35269.07998.3616998.78111002.6031020.258 1031.681032.4481080.2711387.0771778.837
2103.8082405.2812691.1593062.5283413.1953758.6064120.3914527.0184930.4845318.963
5743.9416224.096 6656.637051.7857460.2317827.7778071.3878211.2398746.50711983.54
17904.1221766.4722998.9425696.9627624.8530061.2932239.0633931.4534860.9735275.11
35309.7735163.1434849.5234449.4633955.7933358.7832711.4931983.9431356.2930695.07
29909.97   2905428426.6427894.0827161.4826417.0525655.9924968.4224305.4123556.97
22770.8321832.44 20845.320178.7919322.6718513.5217784.1316976.8716100.0915200.73
14489.6213718.2912868.6412028.2311105.6510163.73
River Rch & RM=Bald Eagle,Loc Hav         ,13326.74
35268.62998.2755998.78791001.9911019.0231031.2691032.3941072.9741358.9351756.328
2082.9192391.9932671.2193041.0473389.2653739.2354101.4414505.5434909.644 5298.43
 5719.296198.9996631.9117028.9077436.7687806.2738055.6098192.4588680.98611695.67
 17306.821209.7322641.2625415.4127402.6429847.7832073.1633801.82 34789.7 35243.7
35302.5335170.37 34867.534473.8733986.9333396.2932752.7232029.2431402.2630744.46
29966.4229115.1828473.7327937.0927212.2626471.08 25718.225031.8424367.9623624.64
22840.3421920.0320928.9820251.6819398.5818588.76 17854.817054.7716181.9915301.91
14612.0513855.0513021.2712191.8511280.4410357.29
River Rch & RM=Bald Eagle,Loc Hav         ,12035.22
35266.48998.1917998.83451001.5271017.9121030.917 1032.351067.0531334.1651734.556
2062.8092378.9232652.1863019.469 3364.723719.8394082.8024484.2524888.6795278.199
5696.5476175.3396608.2937007.3787416.0327787.1578041.4578175.8148626.34911444.62
16774.7220695.6822316.2825158.2327200.5229653.8831920.16 33682.434724.1335214.44
35295.6335176.9434884.1334496.4734015.4233430.7132790.4832070.82 31444.630789.79
30018.37 29171.428517.1627976.0327258.1326520.0425774.6925089.48 24424.823686.25
22903.2121998.3321005.0720317.6719467.5118656.77 17918.7   1712516255.79 15393.9
14722.8413979.0313160.0912339.0611438.5310529.75
River Rch & RM=Bald Eagle,Loc Hav         ,11865.80
35266.44998.1889998.83251001.4681017.7771030.8691032.3541066.3591331.1461731.898
2060.3582377.2682649.7943016.7423361.615 3717.364080.4484481.6584886.1055275.749
5693.7296172.3796605.4937004.8427413.5137784.8178039.7068174.6758622.81711426.03
16746.8920668.1922299.58 25144.827190.0329644.0631911.8633676.0134720.6535212.81
35295.2535177.2934885.01 34497.734016.88 33432.532792.4332073.0231446.8330792.18
30021.1529174.4128519.5427977.9927260.44 26522.525777.5525092.4924427.7323689.43
22906.3822002.18   2100920321.0619471.0818660.2217921.9317128.5416259.5415398.69
14728.5113985.5113167.3612346.6911446.91 10538.8
River Rch & RM=Bald Eagle,Loc Hav         ,11116.44
35266.22 998.184998.79771001.2491017.2441030.6651032.3221063.5371318.2971720.298
2049.752 2369.812639.2823004.4853347.7593706.7114069.6924469.8944874.3915264.709
5680.9526158.9546592.745 6993.417401.8657773.9718031.5688169.329 8607.0911344.97
16623.6420507.4622186.0525050.4827117.4629576.2531856.6633633.3234697.0535202.09
 35292.835179.54 34890.934505.7734026.7633444.5232805.5932087.5131461.6930808.21
30039.7129194.4628535.1627991.7827276.6226539.5725797.4225113.2724447.9523711.33
22928.5322028.8421036.4720344.7119495.8318683.4617943.5317152.3316284.6415431.11
14760.8214022.5513208.9712385.7511489.9810578.93
River Rch & RM=Bald Eagle,Loc Hav         ,10995.73
35264.36998.1862998.79391001.2141017.1511030.6291032.3191063.0981316.2141718.361
    20482368.5642637.5743002.4443345.4843705.0284067.9364467.9824872.4955262.939
5678.8856156.7776590.6736991.5637399.9897772.233 8030.258168.4758604.652 11333.6
16606.4520473.6722162.8625030.9927102.4529562.2331845.5333624.7534692.2635199.95
35292.3135179.9734892.0734507.3934028.7833446.9632808.2132090.42 31464.730811.43
30043.44 29198.528538.3127994.6127279.9526543.0925801.5425117.5524452.1223715.85
22933.0822034.2821042.1420349.5719500.9218688.35 17947.917157.1916289.7115437.73
14767.4814030.1913217.5712392.7911497.7810584.55
River Rch & RM=Bald Eagle,Loc Hav         ,10221.14
35262.38998.1958 998.7941000.9811016.4771030.3481032.2971060.2441302.5391705.621
2036.9252359.2552625.5282988.0893328.7553693.2024056.1664455.2614859.8715249.817
5664.0286141.0456575.7246977.467 7385.947759.2358020.3668162.0518583.64711236.89
16399.3220188.6321989.4424886.5926992.2829455.7531762.15 33558.934655.9335183.63
35288.6135183.3234900.79 34519.634044.0233465.4232828.2332112.7631487.63   30836
 30071.329228.6428561.7528015.8127305.0926569.6725832.8225148.7424482.6223748.85
 22966.722073.8821084.0620384.2319537.2818724.6617980.5817193.2916326.1915485.34
14823.21 14094.113287.1712458.8811568.1610651.58
River Rch & RM=Bald Eagle,Loc Hav         ,9258.941
35263.85998.1851998.7922  1000.71015.532 1029.861032.2611056.7361284.5371687.944
2022.7942345.2362609.1442968.0623305.5093677.9464041.3524439.0954843.7575233.076
5645.8556120.6196556.318 6959.397368.3897737.6888004.0018151.3748551.95211076.13
16058.7619734.38 21716.324665.1626823.7529290.7131633.5233457.5934599.6935158.13
35282.6435188.5734914.55 34538.334067.4833493.8932859.8532147.1331522.8630873.99
30113.8529275.1628598.2628048.5427343.8226610.1725880.0625196.4124529.4623799.26
23018.8722133.6421147.4720436.9419592.6418779.6618030.7217248.5116382.2215559.01
14910.4414194.2413397.3712571.6111689.5510761.38
River Rch & RM=Bald Eagle,Loc Hav         ,8541.462
35262.07998.1572998.75291000.4761014.6821029.363 1032.231054.0051269.0531671.989
2010.6882333.2862595.5392951.126 3286.853665.924 4029.744426.5034831.1565219.785
5631.5646104.5736540.9976941.721 7351.257717.597 7988.658141.5428522.89110929.24
 15754.219294.1621462.8524462.1226669.3529144.4331516.7133367.54 34550.135135.73
35277.2235193.09 34926.834554.8234088.4533519.2232887.5732177.6531554.3930907.65
30152.3729316.45 28630.528077.5227378.4126646.1325922.1325240.0324571.8223845.08
23066.1322187.7821205.2520486.0419643.8618830.0918077.2417299.6916435.6415629.08
14993.83 14290.1 13503.512681.0511794.7810859.83
River Rch & RM=Bald Eagle,Loc Hav         ,7936.130
35261.73 998.134998.72371000.3161013.9851028.9581032.2021051.9341256.7651658.694
2000.8462323.3922583.3552935.9823270.4653653.7534017.9994414.0634818.6475204.316
5615.046 6086.696523.9436920.9827331.2337698.6097974.0378132.2728496.21410791.53
15418.2118874.3321227.3724267.7226525.0729008.7831408.5833283.8534504.5735115.32
35272.2335197.1134937.9534570.0534107.5233542.5432912.8332205.9431583.6430938.96
30188.0429354.5728660.2728104.3427410.5426680.0125961.96 25281.424611.3223887.91
23110.1622239.1821260.2220531.61 19691.418876.8918120.9217347.8816485.2915694.48
 15073.114381.2213603.2712787.6811891.6210969.06
River Rch & RM=Bald Eagle,Loc Hav         ,6940.066
35262.46998.0454 998.681 1000.121012.9611028.3481032.1651049.1181239.5181639.252
1986.3612308.2162565.0322912.1513245.555 3635.634000.2874395.269 4799.765182.403
5589.5726058.8886497.4776894.1627294.5667664.0257947.4178115.3478455.36110527.02
14778.5218169.7220837.4923943.29 26290.128787.4531236.0233149.7134431.5535082.58
35264.38 35203.734955.5634594.47 34137.533579.8532953.8532251.3631630.0630989.24
30244.6829416.69   2870928148.2127462.6326735.3126026.88 25348.924676.1123958.36
23182.3822323.3521350.6320606.3919769.7318954.3818193.1217427.8516567.0615803.34
15205.0314533.2713773.0412969.6212076.0511156.12
River Rch & RM=Bald Eagle,Loc Hav         ,6267.489
35261.16997.9193998.6544999.97631012.262 1027.881032.1111047.352 1228.351626.125
  1976.7 2297.782553.2752896.4423229.923 3624.033988.8984383.188 4787.625167.532
5572.3336040.0956479.5436874.3627268.057  7638.9 7928.168103.1638421.00110325.47
14297.8417663.9320563.0623717.2426128.2728636.5731118.0733058.3134382.0835060.23
35259.1135208.2834967.5334610.8234158.1833605.0532981.8332282.3231661.3831023.56
30283.5529459.3128742.3328178.2227498.1726772.9126071.1825394.8724720.9224007.04
23231.9822380.7921413.04   20659 19824.819008.4518243.98 17483.916625.0315880.94
15299.0814641.5313894.85   1310112212.8811296.35
River Rch & RM=Bald Eagle,Loc Hav         ,5523.234
35260.79997.7597998.6357999.83581011.4861027.3131032.051 1045.581216.1421611.141
1966.2962285.955 2539.96 2879.063212.5483611.2833976.4884365.9484770.2285147.256
5550.8986012.8566453.7026847.1697241.6387611.8937907.4638090.1398384.19710137.05
13852.9217110.7220264.76   2346925952.6328472.94 30990.232959.2534328.3935035.79
35253.2735213.1134980.45 34628.534180.8333632.3533011.6232316.0431695.3831060.61
30325.83 29505.528778.4328210.4127536.6526813.7826119.0425444.5524769.6524059.81
23285.6922443.1821480.5620716.01 19884.819067.0718299.1517544.34 16687.815965.39
15401.7614759.04 14027.513243.6912364.3411437.53
River Rch & RM=Bald Eagle,Loc Hav         ,4293.710
35260.22997.4363998.6259999.62151010.2631026.4041031.9691042.9271196.2451587.198
1948.6562264.3772516.8822847.7013182.9083593.6583959.3014340.8744744.8785122.958
5524.2685977.0196419.824 6812.627208.0567576.8727880.4968073.0838344.7389917.778
13192.1616306.8319835.1623103.3525698.5728237.0530804.6432815.5834250.4635000.05
35244.7135220.1334999.3334654.8934213.4333671.9533054.6432365.1431745.1131114.03
 30386.829572.2128830.7528256.5727591.8426872.9226188.0925516.4724840.1724135.76
23362.9322532.6221577.7520797.9119971.2919151.8318378.2117631.1416778.0416087.67
15549.89   1492914219.7513450.2112591.4111644.52
River Rch & RM=Bald Eagle,Loc Hav         ,3047.378
35259.71997.0361998.5884999.39261009.1321025.5311031.8571040.5821178.0121566.032
1926.4012237.4292488.3042809.4263150.1263574.3513940.5434320.8544723.9945102.917
 5502.085952.0216395.3346786.2697182.5227552.2717860.6238060.4168316.2679758.153
12697.9915816.0419574.0422872.9925542.9428092.5330690.1232726.9534202.3434977.89
35239.4335224.5735011.1134671.3334233.6333696.2733081.4632395.4331775.5931147.63
30424.2129613.2128863.0428284.8827625.7426909.39 26230.525560.8524883.3624182.22
23410.1122586.01 21637.320847.7720023.7719203.1418425.9417683.3116832.3316162.32
15640.0415032.5714336.2713575.5512728.7711798.21
River Rch & RM=Bald Eagle,Loc Hav         ,2731.142
35259.71997.0361998.5884999.39261009.1321025.5311031.8571040.5821178.0121566.032
1926.4012237.4292488.3042809.4263150.1263574.3513940.5434320.8544723.9945102.917
 5502.085952.0216395.3346786.2697182.5227552.2717860.6238060.4168316.2679758.153
12697.9915816.0419574.0422872.9925542.9428092.5330690.1232726.9534202.3434977.89
35239.4335224.5735011.1134671.3334233.6333696.2733081.4632395.4331775.5931147.63
30424.2129613.2128863.0428284.8827625.7426909.39 26230.525560.8524883.3624182.22
23410.1122586.01 21637.320847.7720023.7719203.1418425.9417683.3116832.3316162.32
15640.0415032.5714336.2713575.5512728.7711798.21
River Rch & RM=Bald Eagle,Loc Hav         ,2501.017
 35259.6996.9539998.5826999.37561008.9671025.4121031.8431040.2961174.9811558.979
 1918.252229.1852480.9542799.7843142.5983570.0653936.2984316.409 4719.285098.432
5497.2725946.6376390.0976781.5557178.0317547.8997857.0698058.1868311.2269732.395
12653.0115771.5119550.5122780.52 25506.928057.6230665.7132707.9934192.0234973.18
35238.2835225.4635013.63 34674.8 34237.933701.4833087.1532401.8431782.1631154.23
30432.2929621.9428869.9528291.0327633.9326918.1126240.7825571.0624893.1824192.88
23421.6322609.5221662.5120868.8420045.9719225.4318430.2817688.0416837.1416169.11
15648.2615041.94 14346.913586.91 12741.411812.14
River Rch & RM=Bald Eagle,Loc Hav         ,2371.827
35259.29996.9108998.5787 999.3641008.8681025.334 1031.831040.124 1173.071554.342
1913.2532224.2652476.5562794.1923138.3273567.6263933.9074313.8834716.6485095.919
5494.5965943.6336387.2276778.9937175.5717545.5127855.2138057.0138308.6219719.043
12646.2315768.8419540.3322768.3725484.5228032.9330644.5432690.8534182.7634968.93
35237.2635226.2635015.8734677.8934241.7633706.1833092.2532407.6431787.84   31160
30439.2529629.5628875.9728295.8127639.7126923.5926247.12 25577.3 24899.324199.49
23426.5422612.5221667.1920872.7520050.1319228.5618432.1517688.3216837.4216169.51
15648.75 15042.514347.54 13587.612742.1711814.25
River Rch & RM=Bald Eagle,Loc Hav         ,1692.633
35259.28996.6591998.5737999.30751008.3651024.8221031.7321039.1261161.2861529.556
1885.2542197.6762452.4742764.0123115.0033554.4183920.7584299.9584702.109 5082.12
5477.7245924.6046368.996 6762.757152.6577523.4057837.9968046.2588284.7839555.592
12374.3115501.5818993.8622572.0625348.3627895.1130534.8632604.2734136.18 34947.7
35232.1635230.3535027.23 34693.334261.0233729.6433118.1332436.8831816.71   31190
30475.18 29668.5 28906.328323.1127672.0126958.2926285.93 25615.824936.6224239.36
23469.8422660.4321786.9520973.2820156.8719335.1618532.67 17715.9 16865.916209.54
15697.5415098.5714410.5913656.1212817.6311898.45
River Rch & RM=Bald Eagle,Loc Hav         ,1212.855
35259.08996.5157998.5408999.28081008.0741024.5091031.6771038.5131153.2021513.092
1866.4882180.2562436.5872744.2013098.9683545.3913911.7224290.3834691.4635072.042
5465.4225910.7646355.1846750.4277135.6467505.7147824.1418037.7258265.802  9404.5
12125.3415257.5718870.5122465.6225274.3627822.8830477.4232558.3634111.3934936.35
35229.41 35232.535033.1634701.5934271.1933742.17 33131.832452.3431832.2531205.58
30494.17   2968928922.3328337.1727688.9826976.5826307.1125636.7724956.8824260.81
23493.2822686.2221814.59 20996.520181.1819359.4418555.3117741.1916891.8716246.11
15742.1215149.8714468.3713718.9312886.7811975.55
River Rch & RM=Bald Eagle,Loc Hav         ,659.942
35259.02996.2008998.5219999.2027  1007.51023.9981031.5971037.575  1142.71489.031
1843.1152157.7292416.7372714.5923076.1793529.1893895.7934273.542 4673.125054.462
5446.7245889.7296334.3096732.0087117.8987487.0517809.5558028.6468245.6569272.851
11914.6515052.9918767.2722376.8425213.8127763.0630430.5332520.6234090.5534926.81
35227.1435234.2535038.2334708.5634279.8633752.6833143.3732465.0831845.26   31218
30509.7429705.8928935.6628348.7927702.9526991.68 26324.525653.8324973.6624278.65
23512.98 22707.921837.6221015.8120201.4419379.8318574.1717762.3616913.5716276.84
15779.5915193.0114517.2413771.8912945.5612040.83
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 1
Up Type= 0
Dn Type= 1
Dn Known WS=564.9562
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 2
Up Type= 0
Dn Type= 1
Dn Known WS=532.7863
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 3
Up Type= 0
Dn Type= 1
Dn Known WS=532.7947
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 4
Up Type= 0
Dn Type= 1
Dn Known WS=532.7972
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 5
Up Type= 0
Dn Type= 1
Dn Known WS=532.8276
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 6
Up Type= 0
Dn Type= 1
Dn Known WS=532.8869
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 7
Up Type= 0
Dn Type= 1
Dn Known WS=532.9138
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 8
Up Type= 0
Dn Type= 1
Dn Known WS=532.9362
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 9
Up Type= 0
Dn Type= 1
Dn Known WS=533.3231
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 10
Up Type= 0
Dn Type= 1
Dn Known WS=534.5791
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 11
Up Type= 0
Dn Type= 1
Dn Known WS=535.8525
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 12
Up Type= 0
Dn Type= 1
Dn Known WS=536.9836
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 13
Up Type= 0
Dn Type= 1
Dn Known WS=537.9139
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 14
Up Type= 0
Dn Type= 1
Dn Known WS=538.9895
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 15
Up Type= 0
Dn Type= 1
Dn Known WS=540.1089
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 16
Up Type= 0
Dn Type= 1
Dn Known WS=540.6846
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 17
Up Type= 0
Dn Type= 1
Dn Known WS=541.1544
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 18
Up Type= 0
Dn Type= 1
Dn Known WS=541.6388
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 19
Up Type= 0
Dn Type= 1
Dn Known WS=542.1511
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 20
Up Type= 0
Dn Type= 1
Dn Known WS=542.6395
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 21
Up Type= 0
Dn Type= 1
Dn Known WS=543.1426
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 22
Up Type= 0
Dn Type= 1
Dn Known WS=543.7112
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 23
Up Type= 0
Dn Type= 1
Dn Known WS=544.2806
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 24
Up Type= 0
Dn Type= 1
Dn Known WS=544.7892
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 25
Up Type= 0
Dn Type= 1
Dn Known WS=545.2837
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 26
Up Type= 0
Dn Type= 1
Dn Known WS=545.7566
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 27
Up Type= 0
Dn Type= 1
Dn Known WS=546.1684
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 28
Up Type= 0
Dn Type= 1
Dn Known WS=546.4473
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 29
Up Type= 0
Dn Type= 1
Dn Known WS=546.7292
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 30
Up Type= 0
Dn Type= 1
Dn Known WS=548.0751
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 31
Up Type= 0
Dn Type= 1
Dn Known WS=551.4907
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 32
Up Type= 0
Dn Type= 1
Dn Known WS=555.5073
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 33
Up Type= 0
Dn Type= 1
Dn Known WS=558.3635
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 34
Up Type= 0
Dn Type= 1
Dn Known WS=560.0091
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 35
Up Type= 0
Dn Type= 1
Dn Known WS=561.2986
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 36
Up Type= 0
Dn Type= 1
Dn Known WS=562.3918
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 37
Up Type= 0
Dn Type= 1
Dn Known WS=563.3587
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 38
Up Type= 0
Dn Type= 1
Dn Known WS=564.1151
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 39
Up Type= 0
Dn Type= 1
Dn Known WS=564.5936
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 40
Up Type= 0
Dn Type= 1
Dn Known WS=564.8531
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 41
Up Type= 0
Dn Type= 1
Dn Known WS=564.9464
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 42
Up Type= 0
Dn Type= 1
Dn Known WS=564.9485
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 43
Up Type= 0
Dn Type= 1
Dn Known WS=564.8863
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 44
Up Type= 0
Dn Type= 1
Dn Known WS=564.7834
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 45
Up Type= 0
Dn Type= 1
Dn Known WS=564.65
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 46
Up Type= 0
Dn Type= 1
Dn Known WS=564.4858
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 47
Up Type= 0
Dn Type= 1
Dn Known WS=564.2963
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 48
Up Type= 0
Dn Type= 1
Dn Known WS=564.0836
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 49
Up Type= 0
Dn Type= 1
Dn Known WS=563.8582
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 50
Up Type= 0
Dn Type= 1
Dn Known WS=563.6309
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 51
Up Type= 0
Dn Type= 1
Dn Known WS=563.3716
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 52
Up Type= 0
Dn Type= 1
Dn Known WS=563.0789
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 53
Up Type= 0
Dn Type= 1
Dn Known WS=562.7999
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 54
Up Type= 0
Dn Type= 1
Dn Known WS=562.587
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 55
Up Type= 0
Dn Type= 1
Dn Known WS=562.3514
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 56
Up Type= 0
Dn Type= 1
Dn Known WS=562.0916
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 57
Up Type= 0
Dn Type= 1
Dn Known WS=561.7859
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 58
Up Type= 0
Dn Type= 1
Dn Known WS=561.4794
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 59
Up Type= 0
Dn Type= 1
Dn Known WS=561.1685
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 60
Up Type= 0
Dn Type= 1
Dn Known WS=560.8505
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 61
Up Type= 0
Dn Type= 1
Dn Known WS=560.4999
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 62
Up Type= 0
Dn Type= 1
Dn Known WS=560.1312
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 63
Up Type= 0
Dn Type= 1
Dn Known WS=559.733
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 64
Up Type= 0
Dn Type= 1
Dn Known WS=559.3584
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 65
Up Type= 0
Dn Type= 1
Dn Known WS=558.9858
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 66
Up Type= 0
Dn Type= 1
Dn Known WS=558.6102
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 67
Up Type= 0
Dn Type= 1
Dn Known WS=558.2424
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 68
Up Type= 0
Dn Type= 1
Dn Known WS=557.8705
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 69
Up Type= 0
Dn Type= 1
Dn Known WS=557.4824
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 70
Up Type= 0
Dn Type= 1
Dn Known WS=557.0045
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 71
Up Type= 0
Dn Type= 1
Dn Known WS=556.3651
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 72
Up Type= 0
Dn Type= 1
Dn Known WS=555.6117
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 73
Up Type= 0
Dn Type= 1
Dn Known WS=554.7438
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 74
Up Type= 0
Dn Type= 1
Dn Known WS=553.7874
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 75
Up Type= 0
Dn Type= 1
Dn Known WS=552.7265
Boundary for River Rch & Prof#=Bald Eagle,Loc Hav         , 76
Up Type= 0
Dn Type= 1
Dn Known WS=551.565
Set Internal Change=Bald Eagle      ,Loc Hav         ,138154.4, 1 , 3 ,672.7281
Set Internal Change=Bald Eagle      ,Loc Hav         ,137690.8, 1 , 3 ,672.6246
Set Internal Change=Bald Eagle      ,Loc Hav         ,137327.0, 1 , 3 ,672.1544
Set Internal Change=Bald Eagle      ,Loc Hav         ,136564.9, 1 , 3 ,668.7034
Set Internal Change=Bald Eagle      ,Loc Hav         ,136202.3, 1 , 3 ,668.2282
Set Internal Change=Bald Eagle      ,Loc Hav         ,135591.4, 1 , 3 ,666.3911
Set Internal Change=Bald Eagle      ,Loc Hav         ,135068.7, 1 , 3 ,665.9804
Set Internal Change=Bald Eagle      ,Loc Hav         ,134487.2, 1 , 3 ,665.3742
Set Internal Change=Bald Eagle      ,Loc Hav         ,133881.0, 1 , 3 ,664.9924
Set Internal Change=Bald Eagle      ,Loc Hav         ,133446.1, 1 , 3 ,664.6759
Set Internal Change=Bald Eagle      ,Loc Hav         ,132973.6, 1 , 3 ,664.4265
Set Internal Change=Bald Eagle      ,Loc Hav         ,132363.8, 1 , 3 ,663.9146
Set Internal Change=Bald Eagle      ,Loc Hav         ,131699.7, 1 , 3 ,663.5026
Set Internal Change=Bald Eagle      ,Loc Hav         ,130997.6, 1 , 3 ,663.2847
Set Internal Change=Bald Eagle      ,Loc Hav         ,130339.2, 1 , 3 ,663.1911
Set Internal Change=Bald Eagle      ,Loc Hav         ,129627.5, 1 , 3 ,663.1316
Set Internal Change=Bald Eagle      ,Loc Hav         ,128760.7, 1 , 3 ,663.094
Set Internal Change=Bald Eagle      ,Loc Hav         ,128280.7, 1 , 3 ,663.0811
Set Internal Change=Bald Eagle      ,Loc Hav         ,127410.9, 1 , 3 ,663.0547
Set Internal Change=Bald Eagle      ,Loc Hav         ,126741.0, 1 , 3 ,663.0225
Set Internal Change=Bald Eagle      ,Loc Hav         ,126454.1, 1 , 3 ,662.9741
Set Internal Change=Bald Eagle      ,Loc Hav         ,126062.6, 1 , 3 ,662.942
Set Internal Change=Bald Eagle      ,Loc Hav         ,125704.7, 1 , 3 ,662.9247
Set Internal Change=Bald Eagle      ,Loc Hav         ,125091.9, 1 , 3 ,662.9019
Set Internal Change=Bald Eagle      ,Loc Hav         ,124615.5, 1 , 3 ,662.8923
Set Internal Change=Bald Eagle      ,Loc Hav         ,124025.0, 1 , 3 ,662.8639
Set Internal Change=Bald Eagle      ,Loc Hav         ,123503.5, 1 , 3 ,662.8501
Set Internal Change=Bald Eagle      ,Loc Hav         ,123123.6, 1 , 3 ,662.8406
Set Internal Change=Bald Eagle      ,Loc Hav         ,122703.3, 1 , 3 ,662.8326
Set Internal Change=Bald Eagle      ,Loc Hav         ,122190.8, 1 , 3 ,662.823
Set Internal Change=Bald Eagle      ,Loc Hav         ,121754.0, 1 , 3 ,662.8145
Set Internal Change=Bald Eagle      ,Loc Hav         ,121394.1, 1 , 3 ,662.8065
Set Internal Change=Bald Eagle      ,Loc Hav         ,120862.6, 1 , 3 ,662.7977
Set Internal Change=Bald Eagle      ,Loc Hav         ,120421.4, 1 , 3 ,662.7824
Set Internal Change=Bald Eagle      ,Loc Hav         ,119954.9, 1 , 3 ,662.7714
Set Internal Change=Bald Eagle      ,Loc Hav         ,119473.8, 1 , 3 ,662.7661
Set Internal Change=Bald Eagle      ,Loc Hav         ,118901.0, 1 , 3 ,662.7606
Set Internal Change=Bald Eagle      ,Loc Hav         ,118300.5, 1 , 3 ,662.753
Set Internal Change=Bald Eagle      ,Loc Hav         ,117753.9, 1 , 3 ,662.7491
Set Internal Change=Bald Eagle      ,Loc Hav         ,117180.8, 1 , 3 ,662.7488
Set Internal Change=Bald Eagle      ,Loc Hav         ,116401.3, 1 , 3 ,662.749
Set Internal Change=Bald Eagle      ,Loc Hav         ,115584.2, 1 , 3 ,662.7464
Set Internal Change=Bald Eagle      ,Loc Hav         ,114899.8, 1 , 3 ,662.7451
Set Internal Change=Bald Eagle      ,Loc Hav         ,113985.6, 1 , 3 ,662.7428
Set Internal Change=Bald Eagle      ,Loc Hav         ,112856.9, 1 , 3 ,662.7408
Set Internal Change=Bald Eagle      ,Loc Hav         ,111971.0, 1 , 3 ,662.74
Set Internal Change=Bald Eagle      ,Loc Hav         ,110657.4, 1 , 3 ,662.7377
Set Internal Change=Bald Eagle      ,Loc Hav         ,109659.9, 1 , 3 ,662.7357
Set Internal Change=Bald Eagle      ,Loc Hav         ,108600.1, 1 , 3 ,662.734
Set Internal Change=Bald Eagle      ,Loc Hav         ,107333.6, 1 , 3 ,662.7321
Set Internal Change=Bald Eagle      ,Loc Hav         ,106466.0, 1 , 3 ,662.7309
Set Internal Change=Bald Eagle      ,Loc Hav         ,105178.6, 1 , 3 ,662.7302
Set Internal Change=Bald Eagle      ,Loc Hav         ,104647.2, 1 , 3 ,662.7289
Set Internal Change=Bald Eagle      ,Loc Hav         ,104195.0, 1 , 3 ,662.7281
Set Internal Change=Bald Eagle      ,Loc Hav         ,103854.0, 1 , 3 ,662.7277
Set Internal Change=Bald Eagle      ,Loc Hav         ,103369.7, 1 , 3 ,662.7272
Set Internal Change=Bald Eagle      ,Loc Hav         ,103122.3, 1 , 3 ,662.7036
Set Internal Change=Bald Eagle      ,Loc Hav         ,101440.3, 1 , 3 ,662.7023
Set Internal Change=Bald Eagle      ,Loc Hav         ,100657.3, 1 , 3 ,662.702
Set Internal Change=Bald Eagle      ,Loc Hav         ,99452.75, 1 , 3 ,662.7014
Set Internal Change=Bald Eagle      ,Loc Hav         ,98206.87, 1 , 3 ,662.7012
Set Internal Change=Bald Eagle      ,Loc Hav         ,97607.35, 1 , 3 ,662.6996
Set Internal Change=Bald Eagle      ,Loc Hav         ,96370.43, 1 , 3 ,662.7003
Set Internal Change=Bald Eagle      ,Loc Hav         ,94560.01, 1 , 3 ,662.6995
Set Internal Change=Bald Eagle      ,Loc Hav         ,93391.71, 1 , 3 ,662.6985
Set Internal Change=Bald Eagle      ,Loc Hav         ,92011.85, 1 , 3 ,662.6975
Set Internal Change=Bald Eagle      ,Loc Hav         ,91030.01, 1 , 3 ,662.6971
Set Internal Change=Bald Eagle      ,Loc Hav         ,90096.99, 1 , 3 ,662.6974
Set Internal Change=Bald Eagle      ,Loc Hav         ,89060.69, 1 , 3 ,662.6973
Set Internal Change=Bald Eagle      ,Loc Hav         ,87861.14, 1 , 3 ,662.6972
Set Internal Change=Bald Eagle      ,Loc Hav         ,86942.04, 1 , 3 ,662.6971
Set Internal Change=Bald Eagle      ,Loc Hav         ,85569.53, 1 , 3 ,662.6972
Set Internal Change=Bald Eagle      ,Loc Hav         ,84724.08, 1 , 3 ,662.697
Set Internal Change=Bald Eagle      ,Loc Hav         ,83563.41, 1 , 3 ,662.6968
Set Internal Change=Bald Eagle      ,Loc Hav         ,82607.89, 1 , 3 ,662.6966
Set Internal Change=Bald Eagle      ,Loc Hav         ,81849.41, 1 , 3 ,662.6959
Set Internal Change=Bald Eagle      ,Loc Hav         ,81084.18, 1 , 3 ,607.3735
Set Internal Change=Bald Eagle      ,Loc Hav         ,80500.50, 1 , 3 ,599.6994
Set Internal Change=Bald Eagle      ,Loc Hav         ,79684.28, 1 , 3 ,597.9435
Set Internal Change=Bald Eagle      ,Loc Hav         ,78627.87, 1 , 3 ,596.6886
Set Internal Change=Bald Eagle      ,Loc Hav         ,76643.40, 1 , 3 ,595.5751
Set Internal Change=Bald Eagle      ,Loc Hav         ,76002.96, 1 , 3 ,595.3255
Set Internal Change=Bald Eagle      ,Loc Hav         ,75917.82, 1 , 3 ,594.0978
Set Internal Change=Bald Eagle      ,Loc Hav         ,75616.14, 1 , 3 ,593.7574
Set Internal Change=Bald Eagle      ,Loc Hav         ,74650.60, 1 , 3 ,592.8226
Set Internal Change=Bald Eagle      ,Loc Hav         ,74207.96, 1 , 3 ,592.5279
Set Internal Change=Bald Eagle      ,Loc Hav         ,73504.24, 1 , 3 ,592.2222
Set Internal Change=Bald Eagle      ,Loc Hav         ,72303.68, 1 , 3 ,591.7984
Set Internal Change=Bald Eagle      ,Loc Hav         ,71400.81, 1 , 3 ,591.4398
Set Internal Change=Bald Eagle      ,Loc Hav         ,70651.52, 1 , 3 ,590.9788
Set Internal Change=Bald Eagle      ,Loc Hav         ,69567.33, 1 , 3 ,590.0914
Set Internal Change=Bald Eagle      ,Loc Hav         ,68604.09, 1 , 3 ,589.4486
Set Internal Change=Bald Eagle      ,Loc Hav         ,67326.78, 1 , 3 ,588.604
Set Internal Change=Bald Eagle      ,Loc Hav         ,66070.17, 1 , 3 ,587.6669
Set Internal Change=Bald Eagle      ,Loc Hav         ,64908.02, 1 , 3 ,586.7968
Set Internal Change=Bald Eagle      ,Loc Hav         ,63812.99, 1 , 3 ,585.8592
Set Internal Change=Bald Eagle      ,Loc Hav         ,62746.41, 1 , 3 ,585.1284
Set Internal Change=Bald Eagle      ,Loc Hav         ,61896.89, 1 , 3 ,584.7269
Set Internal Change=Bald Eagle      ,Loc Hav         ,60901.09, 1 , 3 ,584.2358
Set Internal Change=Bald Eagle      ,Loc Hav         ,59795.28, 1 , 3 ,583.5927
Set Internal Change=Bald Eagle      ,Loc Hav         ,58836.23, 1 , 3 ,582.4902
Set Internal Change=Bald Eagle      ,Loc Hav         ,58708.54, 1 , 3 ,581.6404
Set Internal Change=Bald Eagle      ,Loc Hav         ,58091.91, 1 , 3 ,581.1442
Set Internal Change=Bald Eagle      ,Loc Hav         ,57700.27, 1 , 3 ,580.8142
Set Internal Change=Bald Eagle      ,Loc Hav         ,57250.60, 1 , 3 ,580.3586
Set Internal Change=Bald Eagle      ,Loc Hav         ,56775.92, 1 , 3 ,579.8574
Set Internal Change=Bald Eagle      ,Loc Hav         ,56243.79, 1 , 3 ,579.3494
Set Internal Change=Bald Eagle      ,Loc Hav         ,55700.55, 1 , 3 ,578.9312
Set Internal Change=Bald Eagle      ,Loc Hav         ,54696.51, 1 , 3 ,578.0204
Set Internal Change=Bald Eagle      ,Loc Hav         ,53922.53, 1 , 3 ,577.3349
Set Internal Change=Bald Eagle      ,Loc Hav         ,52879.19, 1 , 3 ,576.6725
Set Internal Change=Bald Eagle      ,Loc Hav         ,51784.74, 1 , 3 ,575.9517
Set Internal Change=Bald Eagle      ,Loc Hav         ,50720.68, 1 , 3 ,575.2756
Set Internal Change=Bald Eagle      ,Loc Hav         ,49715.77, 1 , 3 ,574.9887
Set Internal Change=Bald Eagle      ,Loc Hav         ,48965.94, 1 , 3 ,574.8611
Set Internal Change=Bald Eagle      ,Loc Hav         ,48110.09, 1 , 3 ,574.5511
Set Internal Change=Bald Eagle      ,Loc Hav         ,47453.14, 1 , 3 ,574.2959
Set Internal Change=Bald Eagle      ,Loc Hav         ,46722.59, 1 , 3 ,574.0992
Set Internal Change=Bald Eagle      ,Loc Hav         ,46310.48, 1 , 3 ,573.9644
Set Internal Change=Bald Eagle      ,Loc Hav         ,45805.37, 1 , 3 ,573.8288
Set Internal Change=Bald Eagle      ,Loc Hav         ,45233.89, 1 , 3 ,573.7002
Set Internal Change=Bald Eagle      ,Loc Hav         ,44529.29, 1 , 3 ,573.5624
Set Internal Change=Bald Eagle      ,Loc Hav         ,43919.30, 1 , 3 ,573.4708
Set Internal Change=Bald Eagle      ,Loc Hav         ,42895.87, 1 , 3 ,573.3469
Set Internal Change=Bald Eagle      ,Loc Hav         ,41806.43, 1 , 3 ,573.22
Set Internal Change=Bald Eagle      ,Loc Hav         ,40526.85, 1 , 3 ,573.0935
Set Internal Change=Bald Eagle      ,Loc Hav         ,39499.37, 1 , 3 ,572.9714
Set Internal Change=Bald Eagle      ,Loc Hav         ,38446.87, 1 , 3 ,572.7367
Set Internal Change=Bald Eagle      ,Loc Hav         ,37962.54, 1 , 3 ,572.5638
Set Internal Change=Bald Eagle      ,Loc Hav         ,37385.23, 1 , 3 ,572.3345
Set Internal Change=Bald Eagle      ,Loc Hav         ,36769.88, 1 , 3 ,572.1243
Set Internal Change=Bald Eagle      ,Loc Hav         ,36663.76, 1 , 3 ,569.7989
Set Internal Change=Bald Eagle      ,Loc Hav         ,36339.56, 1 , 3 ,569.7783
Set Internal Change=Bald Eagle      ,Loc Hav         ,35648.50, 1 , 3 ,569.556
Set Internal Change=Bald Eagle      ,Loc Hav         ,35072.37, 1 , 3 ,569.3967
Set Internal Change=Bald Eagle      ,Loc Hav         ,34098.93, 1 , 3 ,569.2391
Set Internal Change=Bald Eagle      ,Loc Hav         ,33498.68, 1 , 3 ,569.1734
Set Internal Change=Bald Eagle      ,Loc Hav         ,32195.47, 1 , 3 ,569.0379
Set Internal Change=Bald Eagle      ,Loc Hav         ,30878.12, 1 , 3 ,568.9543
Set Internal Change=Bald Eagle      ,Loc Hav         ,29563.77, 1 , 3 ,568.9015
Set Internal Change=Bald Eagle      ,Loc Hav         ,27226.40, 1 , 3 ,568.8032
Set Internal Change=Bald Eagle      ,Loc Hav         ,25960.70, 1 , 3 ,568.7699
Set Internal Change=Bald Eagle      ,Loc Hav         ,24843.25, 1 , 3 ,568.7552
Set Internal Change=Bald Eagle      ,Loc Hav         ,24417.73, 1 , 3 ,568.75
Set Internal Change=Bald Eagle      ,Loc Hav         ,23872.06, 1 , 3 ,568.7296
Set Internal Change=Bald Eagle      ,Loc Hav         ,23783.65, 1 , 3 ,568.7184
Set Internal Change=Bald Eagle      ,Loc Hav         ,23384.79, 1 , 3 ,568.7077
Set Internal Change=Bald Eagle      ,Loc Hav         ,22982.97, 1 , 3 ,568.6948
Set Internal Change=Bald Eagle      ,Loc Hav         ,22386.15, 1 , 3 ,568.6468
Set Internal Change=Bald Eagle      ,Loc Hav         ,21283.34, 1 , 3 ,568.5273
Set Internal Change=Bald Eagle      ,Loc Hav         ,21199.93, 1 , 3 ,567.9798
Set Internal Change=Bald Eagle      ,Loc Hav         ,20127.30, 1 , 3 ,567.4741
Set Internal Change=Bald Eagle      ,Loc Hav         ,19036.24, 1 , 3 ,566.9772
Set Internal Change=Bald Eagle      ,Loc Hav         ,18200.10, 1 , 3 ,567.0383
Set Internal Change=Bald Eagle      ,Loc Hav         ,17549.23, 1 , 3 ,566.994
Set Internal Change=Bald Eagle      ,Loc Hav         ,16787.45, 1 , 3 ,566.791
Set Internal Change=Bald Eagle      ,Loc Hav         ,15407.88, 1 , 3 ,566.3832
Set Internal Change=Bald Eagle      ,Loc Hav         ,14814.34, 1 , 3 ,566.0648
Set Internal Change=Bald Eagle      ,Loc Hav         ,13326.74, 1 , 3 ,566.0256
Set Internal Change=Bald Eagle      ,Loc Hav         ,12035.22, 1 , 3 ,565.7502
Set Internal Change=Bald Eagle      ,Loc Hav         ,11865.80, 1 , 3 ,565.7311
Set Internal Change=Bald Eagle      ,Loc Hav         ,11116.44, 1 , 3 ,565.6946
Set Internal Change=Bald Eagle      ,Loc Hav         ,10995.73, 1 , 3 ,565.6841
Set Internal Change=Bald Eagle      ,Loc Hav         ,10221.14, 1 , 3 ,565.6557
Set Internal Change=Bald Eagle      ,Loc Hav         ,9258.941, 1 , 3 ,565.5969
Set Internal Change=Bald Eagle      ,Loc Hav         ,8541.462, 1 , 3 ,565.5767
Set Internal Change=Bald Eagle      ,Loc Hav         ,7936.130, 1 , 3 ,565.5508
Set Internal Change=Bald Eagle      ,Loc Hav         ,6940.066, 1 , 3 ,565.516
Set Internal Change=Bald Eagle      ,Loc Hav         ,6267.489, 1 , 3 ,565.5
Set Internal Change=Bald Eagle      ,Loc Hav         ,5523.234, 1 , 3 ,565.4712
Set Internal Change=Bald Eagle      ,Loc Hav         ,4293.710, 1 , 3 ,565.4089
Set Internal Change=Bald Eagle      ,Loc Hav         ,3047.378, 1 , 3 ,565.168
Set Internal Change=Bald Eagle      ,Loc Hav         ,2731.142, 1 , 3 ,565.0566
Set Internal Change=Bald Eagle      ,Loc Hav         ,2501.017, 1 , 3 ,565.1667
Set Internal Change=Bald Eagle      ,Loc Hav         ,2371.827, 1 , 3 ,565.0527
Set Internal Change=Bald Eagle      ,Loc Hav         ,1692.633, 1 , 3 ,565.0346
Set Internal Change=Bald Eagle      ,Loc Hav         ,1212.855, 1 , 3 ,564.9882
Set Internal Change=Bald Eagle      ,Loc Hav         ,659.942 , 1 , 3 ,564.9562
Set Internal Change=Bald Eagle      ,Loc Hav         ,138154.4, 2 , 3 ,659.299
Set Internal Change=Bald Eagle      ,Loc Hav         ,137690.8, 2 , 3 ,658.4554
Set Internal Change=Bald Eagle      ,Loc Hav         ,137327.0, 2 , 3 ,658.105
Set Internal Change=Bald Eagle      ,Loc Hav         ,136564.9, 2 , 3 ,657.0002
Set Internal Change=Bald Eagle      ,Loc Hav         ,136202.3, 2 , 3 ,656.2646
Set Internal Change=Bald Eagle      ,Loc Hav         ,135591.4, 2 , 3 ,655.5237
Set Internal Change=Bald Eagle      ,Loc Hav         ,135068.7, 2 , 3 ,654.6868
Set Internal Change=Bald Eagle      ,Loc Hav         ,134487.2, 2 , 3 ,653.2856
Set Internal Change=Bald Eagle      ,Loc Hav         ,133881.0, 2 , 3 ,652.4658
Set Internal Change=Bald Eagle      ,Loc Hav         ,133446.1, 2 , 3 ,651.7241
Set Internal Change=Bald Eagle      ,Loc Hav         ,132973.6, 2 , 3 ,650.8527
Set Internal Change=Bald Eagle      ,Loc Hav         ,132363.8, 2 , 3 ,650.2885
Set Internal Change=Bald Eagle      ,Loc Hav         ,131699.7, 2 , 3 ,649.0724
Set Internal Change=Bald Eagle      ,Loc Hav         ,130997.6, 2 , 3 ,647.2455
Set Internal Change=Bald Eagle      ,Loc Hav         ,130339.2, 2 , 3 ,646.3228
Set Internal Change=Bald Eagle      ,Loc Hav         ,129627.5, 2 , 3 ,645.6797
Set Internal Change=Bald Eagle      ,Loc Hav         ,128760.7, 2 , 3 ,644.3067
Set Internal Change=Bald Eagle      ,Loc Hav         ,128280.7, 2 , 3 ,643.2118
Set Internal Change=Bald Eagle      ,Loc Hav         ,127410.9, 2 , 3 ,641.3174
Set Internal Change=Bald Eagle      ,Loc Hav         ,126741.0, 2 , 3 ,639.9461
Set Internal Change=Bald Eagle      ,Loc Hav         ,126454.1, 2 , 3 ,639.4366
Set Internal Change=Bald Eagle      ,Loc Hav         ,126062.6, 2 , 3 ,638.9209
Set Internal Change=Bald Eagle      ,Loc Hav         ,125704.7, 2 , 3 ,638.5325
Set Internal Change=Bald Eagle      ,Loc Hav         ,125091.9, 2 , 3 ,637.6324
Set Internal Change=Bald Eagle      ,Loc Hav         ,124615.5, 2 , 3 ,637.2292
Set Internal Change=Bald Eagle      ,Loc Hav         ,124025.0, 2 , 3 ,635.8607
Set Internal Change=Bald Eagle      ,Loc Hav         ,123503.5, 2 , 3 ,634.094
Set Internal Change=Bald Eagle      ,Loc Hav         ,123123.6, 2 , 3 ,633.3687
Set Internal Change=Bald Eagle      ,Loc Hav         ,122703.3, 2 , 3 ,632.8217
Set Internal Change=Bald Eagle      ,Loc Hav         ,122190.8, 2 , 3 ,631.8541
Set Internal Change=Bald Eagle      ,Loc Hav         ,121754.0, 2 , 3 ,631.1801
Set Internal Change=Bald Eagle      ,Loc Hav         ,121394.1, 2 , 3 ,630.9029
Set Internal Change=Bald Eagle      ,Loc Hav         ,120862.6, 2 , 3 ,630.363
Set Internal Change=Bald Eagle      ,Loc Hav         ,120421.4, 2 , 3 ,629.865
Set Internal Change=Bald Eagle      ,Loc Hav         ,119954.9, 2 , 3 ,629.58
Set Internal Change=Bald Eagle      ,Loc Hav         ,119473.8, 2 , 3 ,629.0227
Set Internal Change=Bald Eagle      ,Loc Hav         ,118901.0, 2 , 3 ,627.2305
Set Internal Change=Bald Eagle      ,Loc Hav         ,118300.5, 2 , 3 ,625.9003
Set Internal Change=Bald Eagle      ,Loc Hav         ,117753.9, 2 , 3 ,625.6785
Set Internal Change=Bald Eagle      ,Loc Hav         ,117180.8, 2 , 3 ,625.5837
Set Internal Change=Bald Eagle      ,Loc Hav         ,116401.3, 2 , 3 ,625.4548
Set Internal Change=Bald Eagle      ,Loc Hav         ,115584.2, 2 , 3 ,625.1534
Set Internal Change=Bald Eagle      ,Loc Hav         ,114899.8, 2 , 3 ,624.6041
Set Internal Change=Bald Eagle      ,Loc Hav         ,113985.6, 2 , 3 ,624.0592
Set Internal Change=Bald Eagle      ,Loc Hav         ,112856.9, 2 , 3 ,623.9018
Set Internal Change=Bald Eagle      ,Loc Hav         ,111971.0, 2 , 3 ,621.9935
Set Internal Change=Bald Eagle      ,Loc Hav         ,110657.4, 2 , 3 ,618.9811
Set Internal Change=Bald Eagle      ,Loc Hav         ,109659.9, 2 , 3 ,618.3668
Set Internal Change=Bald Eagle      ,Loc Hav         ,108600.1, 2 , 3 ,617.9468
Set Internal Change=Bald Eagle      ,Loc Hav         ,107333.6, 2 , 3 ,616.2201
Set Internal Change=Bald Eagle      ,Loc Hav         ,106466.0, 2 , 3 ,615.0434
Set Internal Change=Bald Eagle      ,Loc Hav         ,105178.6, 2 , 3 ,614.7855
Set Internal Change=Bald Eagle      ,Loc Hav         ,104647.2, 2 , 3 ,614.4017
Set Internal Change=Bald Eagle      ,Loc Hav         ,104195.0, 2 , 3 ,614.1194
Set Internal Change=Bald Eagle      ,Loc Hav         ,103854.0, 2 , 3 ,614.0822
Set Internal Change=Bald Eagle      ,Loc Hav         ,103369.7, 2 , 3 ,614.0443
Set Internal Change=Bald Eagle      ,Loc Hav         ,103122.3, 2 , 3 ,613.9663
Set Internal Change=Bald Eagle      ,Loc Hav         ,101440.3, 2 , 3 ,611.7535
Set Internal Change=Bald Eagle      ,Loc Hav         ,100657.3, 2 , 3 ,610.6667
Set Internal Change=Bald Eagle      ,Loc Hav         ,99452.75, 2 , 3 ,610.1122
Set Internal Change=Bald Eagle      ,Loc Hav         ,98206.87, 2 , 3 ,609.5247
Set Internal Change=Bald Eagle      ,Loc Hav         ,97607.35, 2 , 3 ,608.5599
Set Internal Change=Bald Eagle      ,Loc Hav         ,96370.43, 2 , 3 ,605.942
Set Internal Change=Bald Eagle      ,Loc Hav         ,94560.01, 2 , 3 ,603.2515
Set Internal Change=Bald Eagle      ,Loc Hav         ,93391.71, 2 , 3 ,601.7292
Set Internal Change=Bald Eagle      ,Loc Hav         ,92011.85, 2 , 3 ,600.5682
Set Internal Change=Bald Eagle      ,Loc Hav         ,91030.01, 2 , 3 ,599.3347
Set Internal Change=Bald Eagle      ,Loc Hav         ,90096.99, 2 , 3 ,598.1203
Set Internal Change=Bald Eagle      ,Loc Hav         ,89060.69, 2 , 3 ,597.6909
Set Internal Change=Bald Eagle      ,Loc Hav         ,87861.14, 2 , 3 ,597.4032
Set Internal Change=Bald Eagle      ,Loc Hav         ,86942.04, 2 , 3 ,597.3419
Set Internal Change=Bald Eagle      ,Loc Hav         ,85569.53, 2 , 3 ,597.3294
Set Internal Change=Bald Eagle      ,Loc Hav         ,84724.08, 2 , 3 ,597.3256
Set Internal Change=Bald Eagle      ,Loc Hav         ,83563.41, 2 , 3 ,597.3237
Set Internal Change=Bald Eagle      ,Loc Hav         ,82607.89, 2 , 3 ,597.323
Set Internal Change=Bald Eagle      ,Loc Hav         ,81849.41, 2 , 3 ,596.5001
Set Internal Change=Bald Eagle      ,Loc Hav         ,81084.18, 2 , 3 ,587.4902
Set Internal Change=Bald Eagle      ,Loc Hav         ,80500.50, 2 , 3 ,585.9815
Set Internal Change=Bald Eagle      ,Loc Hav         ,79684.28, 2 , 3 ,585.516
Set Internal Change=Bald Eagle      ,Loc Hav         ,78627.87, 2 , 3 ,585.2964
Set Internal Change=Bald Eagle      ,Loc Hav         ,76643.40, 2 , 3 ,583.6685
Set Internal Change=Bald Eagle      ,Loc Hav         ,76002.96, 2 , 3 ,582.6601
Set Internal Change=Bald Eagle      ,Loc Hav         ,75917.82, 2 , 3 ,582.4339
Set Internal Change=Bald Eagle      ,Loc Hav         ,75616.14, 2 , 3 ,581.9171
Set Internal Change=Bald Eagle      ,Loc Hav         ,74650.60, 2 , 3 ,581.152
Set Internal Change=Bald Eagle      ,Loc Hav         ,74207.96, 2 , 3 ,580.8315
Set Internal Change=Bald Eagle      ,Loc Hav         ,73504.24, 2 , 3 ,580.1297
Set Internal Change=Bald Eagle      ,Loc Hav         ,72303.68, 2 , 3 ,578.9263
Set Internal Change=Bald Eagle      ,Loc Hav         ,71400.81, 2 , 3 ,577.9999
Set Internal Change=Bald Eagle      ,Loc Hav         ,70651.52, 2 , 3 ,577.2981
Set Internal Change=Bald Eagle      ,Loc Hav         ,69567.33, 2 , 3 ,576.5341
Set Internal Change=Bald Eagle      ,Loc Hav         ,68604.09, 2 , 3 ,576.0538
Set Internal Change=Bald Eagle      ,Loc Hav         ,67326.78, 2 , 3 ,575.5229
Set Internal Change=Bald Eagle      ,Loc Hav         ,66070.17, 2 , 3 ,574.6459
Set Internal Change=Bald Eagle      ,Loc Hav         ,64908.02, 2 , 3 ,573.4717
Set Internal Change=Bald Eagle      ,Loc Hav         ,63812.99, 2 , 3 ,572.3568
Set Internal Change=Bald Eagle      ,Loc Hav         ,62746.41, 2 , 3 ,571.3102
Set Internal Change=Bald Eagle      ,Loc Hav         ,61896.89, 2 , 3 ,570.3843
Set Internal Change=Bald Eagle      ,Loc Hav         ,60901.09, 2 , 3 ,569.2288
Set Internal Change=Bald Eagle      ,Loc Hav         ,59795.28, 2 , 3 ,567.9745
Set Internal Change=Bald Eagle      ,Loc Hav         ,58836.23, 2 , 3 ,567.2731
Set Internal Change=Bald Eagle      ,Loc Hav         ,58708.54, 2 , 3 ,567.1998
Set Internal Change=Bald Eagle      ,Loc Hav         ,58091.91, 2 , 3 ,566.7802
Set Internal Change=Bald Eagle      ,Loc Hav         ,57700.27, 2 , 3 ,566.4551
Set Internal Change=Bald Eagle      ,Loc Hav         ,57250.60, 2 , 3 ,566.1721
Set Internal Change=Bald Eagle      ,Loc Hav         ,56775.92, 2 , 3 ,565.8033
Set Internal Change=Bald Eagle      ,Loc Hav         ,56243.79, 2 , 3 ,565.3583
Set Internal Change=Bald Eagle      ,Loc Hav         ,55700.55, 2 , 3 ,564.8924
Set Internal Change=Bald Eagle      ,Loc Hav         ,54696.51, 2 , 3 ,564.1348
Set Internal Change=Bald Eagle      ,Loc Hav         ,53922.53, 2 , 3 ,563.6923
Set Internal Change=Bald Eagle      ,Loc Hav         ,52879.19, 2 , 3 ,563.2582
Set Internal Change=Bald Eagle      ,Loc Hav         ,51784.74, 2 , 3 ,562.9189
Set Internal Change=Bald Eagle      ,Loc Hav         ,50720.68, 2 , 3 ,562.7126
Set Internal Change=Bald Eagle      ,Loc Hav         ,49715.77, 2 , 3 ,562.4208
Set Internal Change=Bald Eagle      ,Loc Hav         ,48965.94, 2 , 3 ,562.1475
Set Internal Change=Bald Eagle      ,Loc Hav         ,48110.09, 2 , 3 ,561.3492
Set Internal Change=Bald Eagle      ,Loc Hav         ,47453.14, 2 , 3 ,560.6912
Set Internal Change=Bald Eagle      ,Loc Hav         ,46722.59, 2 , 3 ,560.095
Set Internal Change=Bald Eagle      ,Loc Hav         ,46310.48, 2 , 3 ,559.8342
Set Internal Change=Bald Eagle      ,Loc Hav         ,45805.37, 2 , 3 ,559.648
Set Internal Change=Bald Eagle      ,Loc Hav         ,45233.89, 2 , 3 ,559.4988
Set Internal Change=Bald Eagle      ,Loc Hav         ,44529.29, 2 , 3 ,559.2638
Set Internal Change=Bald Eagle      ,Loc Hav         ,43919.30, 2 , 3 ,559.0532
Set Internal Change=Bald Eagle      ,Loc Hav         ,42895.87, 2 , 3 ,558.4238
Set Internal Change=Bald Eagle      ,Loc Hav         ,41806.43, 2 , 3 ,557.6664
Set Internal Change=Bald Eagle      ,Loc Hav         ,40526.85, 2 , 3 ,556.9463
Set Internal Change=Bald Eagle      ,Loc Hav         ,39499.37, 2 , 3 ,556.5831
Set Internal Change=Bald Eagle      ,Loc Hav         ,38446.87, 2 , 3 ,556.1032
Set Internal Change=Bald Eagle      ,Loc Hav         ,37962.54, 2 , 3 ,555.7717
Set Internal Change=Bald Eagle      ,Loc Hav         ,37385.23, 2 , 3 ,555.5511
Set Internal Change=Bald Eagle      ,Loc Hav         ,36769.88, 2 , 3 ,555.4628
Set Internal Change=Bald Eagle      ,Loc Hav         ,36663.76, 2 , 3 ,555.4193
Set Internal Change=Bald Eagle      ,Loc Hav         ,36339.56, 2 , 3 ,555.2582
Set Internal Change=Bald Eagle      ,Loc Hav         ,35648.50, 2 , 3 ,555.0342
Set Internal Change=Bald Eagle      ,Loc Hav         ,35072.37, 2 , 3 ,554.9283
Set Internal Change=Bald Eagle      ,Loc Hav         ,34098.93, 2 , 3 ,554.6774
Set Internal Change=Bald Eagle      ,Loc Hav         ,33498.68, 2 , 3 ,554.5435
Set Internal Change=Bald Eagle      ,Loc Hav         ,32195.47, 2 , 3 ,553.7625
Set Internal Change=Bald Eagle      ,Loc Hav         ,30878.12, 2 , 3 ,552.8994
Set Internal Change=Bald Eagle      ,Loc Hav         ,29563.77, 2 , 3 ,552.352
Set Internal Change=Bald Eagle      ,Loc Hav         ,27226.40, 2 , 3 ,550.6805
Set Internal Change=Bald Eagle      ,Loc Hav         ,25960.70, 2 , 3 ,548.834
Set Internal Change=Bald Eagle      ,Loc Hav         ,24843.25, 2 , 3 ,547.6977
Set Internal Change=Bald Eagle      ,Loc Hav         ,24417.73, 2 , 3 ,547.5147
Set Internal Change=Bald Eagle      ,Loc Hav         ,23872.06, 2 , 3 ,546.7272
Set Internal Change=Bald Eagle      ,Loc Hav         ,23783.65, 2 , 3 ,546.7001
Set Internal Change=Bald Eagle      ,Loc Hav         ,23384.79, 2 , 3 ,546.5239
Set Internal Change=Bald Eagle      ,Loc Hav         ,22982.97, 2 , 3 ,546.1082
Set Internal Change=Bald Eagle      ,Loc Hav         ,22386.15, 2 , 3 ,545.4546
Set Internal Change=Bald Eagle      ,Loc Hav         ,21283.34, 2 , 3 ,544.9957
Set Internal Change=Bald Eagle      ,Loc Hav         ,21199.93, 2 , 3 ,544.9896
Set Internal Change=Bald Eagle      ,Loc Hav         ,20127.30, 2 , 3 ,544.8171
Set Internal Change=Bald Eagle      ,Loc Hav         ,19036.24, 2 , 3 ,543.1185
Set Internal Change=Bald Eagle      ,Loc Hav         ,18200.10, 2 , 3 ,541.8525
Set Internal Change=Bald Eagle      ,Loc Hav         ,17549.23, 2 , 3 ,541.6586
Set Internal Change=Bald Eagle      ,Loc Hav         ,16787.45, 2 , 3 ,541.5047
Set Internal Change=Bald Eagle      ,Loc Hav         ,15407.88, 2 , 3 ,541.0682
Set Internal Change=Bald Eagle      ,Loc Hav         ,14814.34, 2 , 3 ,540.7062
Set Internal Change=Bald Eagle      ,Loc Hav         ,13326.74, 2 , 3 ,540.1522
Set Internal Change=Bald Eagle      ,Loc Hav         ,12035.22, 2 , 3 ,539.8894
Set Internal Change=Bald Eagle      ,Loc Hav         ,11865.80, 2 , 3 ,539.8629
Set Internal Change=Bald Eagle      ,Loc Hav         ,11116.44, 2 , 3 ,539.4337
Set Internal Change=Bald Eagle      ,Loc Hav         ,10995.73, 2 , 3 ,539.3223
Set Internal Change=Bald Eagle      ,Loc Hav         ,10221.14, 2 , 3 ,538.4237
Set Internal Change=Bald Eagle      ,Loc Hav         ,9258.941, 2 , 3 ,537.6832
Set Internal Change=Bald Eagle      ,Loc Hav         ,8541.462, 2 , 3 ,537.489
Set Internal Change=Bald Eagle      ,Loc Hav         ,7936.130, 2 , 3 ,537.3223
Set Internal Change=Bald Eagle      ,Loc Hav         ,6940.066, 2 , 3 ,536.8295
Set Internal Change=Bald Eagle      ,Loc Hav         ,6267.489, 2 , 3 ,536.4823
Set Internal Change=Bald Eagle      ,Loc Hav         ,5523.234, 2 , 3 ,536.225
Set Internal Change=Bald Eagle      ,Loc Hav         ,4293.710, 2 , 3 ,535.7318
Set Internal Change=Bald Eagle      ,Loc Hav         ,3047.378, 2 , 3 ,534.9653
Set Internal Change=Bald Eagle      ,Loc Hav         ,2731.142, 2 , 3 ,534.3804
Set Internal Change=Bald Eagle      ,Loc Hav         ,2501.017, 2 , 3 ,534.1777
Set Internal Change=Bald Eagle      ,Loc Hav         ,2371.827, 2 , 3 ,534.0185
Set Internal Change=Bald Eagle      ,Loc Hav         ,1692.633, 2 , 3 ,533.7479
Set Internal Change=Bald Eagle      ,Loc Hav         ,1212.855, 2 , 3 ,533.6453
Set Internal Change=Bald Eagle      ,Loc Hav         ,659.942 , 2 , 3 ,532.7863
Set Internal Change=Bald Eagle      ,Loc Hav         ,138154.4, 3 , 3 ,661.7124
Set Internal Change=Bald Eagle      ,Loc Hav         ,137690.8, 3 , 3 ,661.1265
Set Internal Change=Bald Eagle      ,Loc Hav         ,137327.0, 3 , 3 ,660.7161
Set Internal Change=Bald Eagle      ,Loc Hav         ,136564.9, 3 , 3 ,658.8709
Set Internal Change=Bald Eagle      ,Loc Hav         ,136202.3, 3 , 3 ,658.1255
Set Internal Change=Bald Eagle      ,Loc Hav         ,135591.4, 3 , 3 ,657.1697
Set Internal Change=Bald Eagle      ,Loc Hav         ,135068.7, 3 , 3 ,656.4663
Set Internal Change=Bald Eagle      ,Loc Hav         ,134487.2, 3 , 3 ,655.2904
Set Internal Change=Bald Eagle      ,Loc Hav         ,133881.0, 3 , 3 ,654.3742
Set Internal Change=Bald Eagle      ,Loc Hav         ,133446.1, 3 , 3 ,653.6854
Set Internal Change=Bald Eagle      ,Loc Hav         ,132973.6, 3 , 3 ,652.9307
Set Internal Change=Bald Eagle      ,Loc Hav         ,132363.8, 3 , 3 ,652.2463
Set Internal Change=Bald Eagle      ,Loc Hav         ,131699.7, 3 , 3 ,650.6785
Set Internal Change=Bald Eagle      ,Loc Hav         ,130997.6, 3 , 3 ,648.8815
Set Internal Change=Bald Eagle      ,Loc Hav         ,130339.2, 3 , 3 ,647.6404
Set Internal Change=Bald Eagle      ,Loc Hav         ,129627.5, 3 , 3 ,646.7753
Set Internal Change=Bald Eagle      ,Loc Hav         ,128760.7, 3 , 3 ,645.2814
Set Internal Change=Bald Eagle      ,Loc Hav         ,128280.7, 3 , 3 ,644.2219
Set Internal Change=Bald Eagle      ,Loc Hav         ,127410.9, 3 , 3 ,642.1909
Set Internal Change=Bald Eagle      ,Loc Hav         ,126741.0, 3 , 3 ,640.8124
Set Internal Change=Bald Eagle      ,Loc Hav         ,126454.1, 3 , 3 ,640.2213
Set Internal Change=Bald Eagle      ,Loc Hav         ,126062.6, 3 , 3 ,639.5207
Set Internal Change=Bald Eagle      ,Loc Hav         ,125704.7, 3 , 3 ,639.0142
Set Internal Change=Bald Eagle      ,Loc Hav         ,125091.9, 3 , 3 ,638.2085
Set Internal Change=Bald Eagle      ,Loc Hav         ,124615.5, 3 , 3 ,637.8721
Set Internal Change=Bald Eagle      ,Loc Hav         ,124025.0, 3 , 3 ,636.3536
Set Internal Change=Bald Eagle      ,Loc Hav         ,123503.5, 3 , 3 ,634.5115
Set Internal Change=Bald Eagle      ,Loc Hav         ,123123.6, 3 , 3 ,633.7382
Set Internal Change=Bald Eagle      ,Loc Hav         ,122703.3, 3 , 3 ,633.2001
Set Internal Change=Bald Eagle      ,Loc Hav         ,122190.8, 3 , 3 ,632.1781
Set Internal Change=Bald Eagle      ,Loc Hav         ,121754.0, 3 , 3 ,631.4812
Set Internal Change=Bald Eagle      ,Loc Hav         ,121394.1, 3 , 3 ,631.1862
Set Internal Change=Bald Eagle      ,Loc Hav         ,120862.6, 3 , 3 ,630.5986
Set Internal Change=Bald Eagle      ,Loc Hav         ,120421.4, 3 , 3 ,630.0461
Set Internal Change=Bald Eagle      ,Loc Hav         ,119954.9, 3 , 3 ,629.7231
Set Internal Change=Bald Eagle      ,Loc Hav         ,119473.8, 3 , 3 ,629.1618
Set Internal Change=Bald Eagle      ,Loc Hav         ,118901.0, 3 , 3 ,627.3353
Set Internal Change=Bald Eagle      ,Loc Hav         ,118300.5, 3 , 3 ,625.9763
Set Internal Change=Bald Eagle      ,Loc Hav         ,117753.9, 3 , 3 ,625.7457
Set Internal Change=Bald Eagle      ,Loc Hav         ,117180.8, 3 , 3 ,625.6428
Set Internal Change=Bald Eagle      ,Loc Hav         ,116401.3, 3 , 3 ,625.5012
Set Internal Change=Bald Eagle      ,Loc Hav         ,115584.2, 3 , 3 ,625.1826
Set Internal Change=Bald Eagle      ,Loc Hav         ,114899.8, 3 , 3 ,624.6215
Set Internal Change=Bald Eagle      ,Loc Hav         ,113985.6, 3 , 3 ,624.068
Set Internal Change=Bald Eagle      ,Loc Hav         ,112856.9, 3 , 3 ,623.9056
Set Internal Change=Bald Eagle      ,Loc Hav         ,111971.0, 3 , 3 ,621.9997
Set Internal Change=Bald Eagle      ,Loc Hav         ,110657.4, 3 , 3 ,618.9896
Set Internal Change=Bald Eagle      ,Loc Hav         ,109659.9, 3 , 3 ,618.3741
Set Internal Change=Bald Eagle      ,Loc Hav         ,108600.1, 3 , 3 ,617.9542
Set Internal Change=Bald Eagle      ,Loc Hav         ,107333.6, 3 , 3 ,616.2249
Set Internal Change=Bald Eagle      ,Loc Hav         ,106466.0, 3 , 3 ,615.0463
Set Internal Change=Bald Eagle      ,Loc Hav         ,105178.6, 3 , 3 ,614.7877
Set Internal Change=Bald Eagle      ,Loc Hav         ,104647.2, 3 , 3 ,614.403
Set Internal Change=Bald Eagle      ,Loc Hav         ,104195.0, 3 , 3 ,614.1202
Set Internal Change=Bald Eagle      ,Loc Hav         ,103854.0, 3 , 3 ,614.0828
Set Internal Change=Bald Eagle      ,Loc Hav         ,103369.7, 3 , 3 ,614.0447
Set Internal Change=Bald Eagle      ,Loc Hav         ,103122.3, 3 , 3 ,613.9666
Set Internal Change=Bald Eagle      ,Loc Hav         ,101440.3, 3 , 3 ,611.7544
Set Internal Change=Bald Eagle      ,Loc Hav         ,100657.3, 3 , 3 ,610.6689
Set Internal Change=Bald Eagle      ,Loc Hav         ,99452.75, 3 , 3 ,610.1146
Set Internal Change=Bald Eagle      ,Loc Hav         ,98206.87, 3 , 3 ,609.5269
Set Internal Change=Bald Eagle      ,Loc Hav         ,97607.35, 3 , 3 ,608.5624
Set Internal Change=Bald Eagle      ,Loc Hav         ,96370.43, 3 , 3 ,605.9435
Set Internal Change=Bald Eagle      ,Loc Hav         ,94560.01, 3 , 3 ,603.2497
Set Internal Change=Bald Eagle      ,Loc Hav         ,93391.71, 3 , 3 ,601.7262
Set Internal Change=Bald Eagle      ,Loc Hav         ,92011.85, 3 , 3 ,600.562
Set Internal Change=Bald Eagle      ,Loc Hav         ,91030.01, 3 , 3 ,599.3249
Set Internal Change=Bald Eagle      ,Loc Hav         ,90096.99, 3 , 3 ,598.1066
Set Internal Change=Bald Eagle      ,Loc Hav         ,89060.69, 3 , 3 ,597.6743
Set Internal Change=Bald Eagle      ,Loc Hav         ,87861.14, 3 , 3 ,597.3788
Set Internal Change=Bald Eagle      ,Loc Hav         ,86942.04, 3 , 3 ,597.3125
Set Internal Change=Bald Eagle      ,Loc Hav         ,85569.53, 3 , 3 ,597.2997
Set Internal Change=Bald Eagle      ,Loc Hav         ,84724.08, 3 , 3 ,597.2959
Set Internal Change=Bald Eagle      ,Loc Hav         ,83563.41, 3 , 3 ,597.294
Set Internal Change=Bald Eagle      ,Loc Hav         ,82607.89, 3 , 3 ,597.2933
Set Internal Change=Bald Eagle      ,Loc Hav         ,81849.41, 3 , 3 ,596.4656
Set Internal Change=Bald Eagle      ,Loc Hav         ,81084.18, 3 , 3 ,587.4781
Set Internal Change=Bald Eagle      ,Loc Hav         ,80500.50, 3 , 3 ,585.9752
Set Internal Change=Bald Eagle      ,Loc Hav         ,79684.28, 3 , 3 ,585.5139
Set Internal Change=Bald Eagle      ,Loc Hav         ,78627.87, 3 , 3 ,585.2963
Set Internal Change=Bald Eagle      ,Loc Hav         ,76643.40, 3 , 3 ,583.6702
Set Internal Change=Bald Eagle      ,Loc Hav         ,76002.96, 3 , 3 ,582.6687
Set Internal Change=Bald Eagle      ,Loc Hav         ,75917.82, 3 , 3 ,582.4454
Set Internal Change=Bald Eagle      ,Loc Hav         ,75616.14, 3 , 3 ,581.9333
Set Internal Change=Bald Eagle      ,Loc Hav         ,74650.60, 3 , 3 ,581.1744
Set Internal Change=Bald Eagle      ,Loc Hav         ,74207.96, 3 , 3 ,580.8582
Set Internal Change=Bald Eagle      ,Loc Hav         ,73504.24, 3 , 3 ,580.1691
Set Internal Change=Bald Eagle      ,Loc Hav         ,72303.68, 3 , 3 ,578.981
Set Internal Change=Bald Eagle      ,Loc Hav         ,71400.81, 3 , 3 ,578.0608
Set Internal Change=Bald Eagle      ,Loc Hav         ,70651.52, 3 , 3 ,577.3638
Set Internal Change=Bald Eagle      ,Loc Hav         ,69567.33, 3 , 3 ,576.6067
Set Internal Change=Bald Eagle      ,Loc Hav         ,68604.09, 3 , 3 ,576.1317
Set Internal Change=Bald Eagle      ,Loc Hav         ,67326.78, 3 , 3 ,575.6046
Set Internal Change=Bald Eagle      ,Loc Hav         ,66070.17, 3 , 3 ,574.7245
Set Internal Change=Bald Eagle      ,Loc Hav         ,64908.02, 3 , 3 ,573.5403
Set Internal Change=Bald Eagle      ,Loc Hav         ,63812.99, 3 , 3 ,572.4143
Set Internal Change=Bald Eagle      ,Loc Hav         ,62746.41, 3 , 3 ,571.3627
Set Internal Change=Bald Eagle      ,Loc Hav         ,61896.89, 3 , 3 ,570.4391
Set Internal Change=Bald Eagle      ,Loc Hav         ,60901.09, 3 , 3 ,569.2919
Set Internal Change=Bald Eagle      ,Loc Hav         ,59795.28, 3 , 3 ,568.0509
Set Internal Change=Bald Eagle      ,Loc Hav         ,58836.23, 3 , 3 ,567.3547
Set Internal Change=Bald Eagle      ,Loc Hav         ,58708.54, 3 , 3 ,567.2807
Set Internal Change=Bald Eagle      ,Loc Hav         ,58091.91, 3 , 3 ,566.8553
Set Internal Change=Bald Eagle      ,Loc Hav         ,57700.27, 3 , 3 ,566.5249
Set Internal Change=Bald Eagle      ,Loc Hav         ,57250.60, 3 , 3 ,566.2413
Set Internal Change=Bald Eagle      ,Loc Hav         ,56775.92, 3 , 3 ,565.87
Set Internal Change=Bald Eagle      ,Loc Hav         ,56243.79, 3 , 3 ,565.423
Set Internal Change=Bald Eagle      ,Loc Hav         ,55700.55, 3 , 3 ,564.9601
Set Internal Change=Bald Eagle      ,Loc Hav         ,54696.51, 3 , 3 ,564.2098
Set Internal Change=Bald Eagle      ,Loc Hav         ,53922.53, 3 , 3 ,563.7626
Set Internal Change=Bald Eagle      ,Loc Hav         ,52879.19, 3 , 3 ,563.3196
Set Internal Change=Bald Eagle      ,Loc Hav         ,51784.74, 3 , 3 ,562.9719
Set Internal Change=Bald Eagle      ,Loc Hav         ,50720.68, 3 , 3 ,562.7604
Set Internal Change=Bald Eagle      ,Loc Hav         ,49715.77, 3 , 3 ,562.4646
Set Internal Change=Bald Eagle      ,Loc Hav         ,48965.94, 3 , 3 ,562.1874
Set Internal Change=Bald Eagle      ,Loc Hav         ,48110.09, 3 , 3 ,561.3853
Set Internal Change=Bald Eagle      ,Loc Hav         ,47453.14, 3 , 3 ,560.7261
Set Internal Change=Bald Eagle      ,Loc Hav         ,46722.59, 3 , 3 ,560.1273
Set Internal Change=Bald Eagle      ,Loc Hav         ,46310.48, 3 , 3 ,559.8656
Set Internal Change=Bald Eagle      ,Loc Hav         ,45805.37, 3 , 3 ,559.6777
Set Internal Change=Bald Eagle      ,Loc Hav         ,45233.89, 3 , 3 ,559.5264
Set Internal Change=Bald Eagle      ,Loc Hav         ,44529.29, 3 , 3 ,559.2883
Set Internal Change=Bald Eagle      ,Loc Hav         ,43919.30, 3 , 3 ,559.0754
Set Internal Change=Bald Eagle      ,Loc Hav         ,42895.87, 3 , 3 ,558.4429
Set Internal Change=Bald Eagle      ,Loc Hav         ,41806.43, 3 , 3 ,557.6808
Set Internal Change=Bald Eagle      ,Loc Hav         ,40526.85, 3 , 3 ,556.9564
Set Internal Change=Bald Eagle      ,Loc Hav         ,39499.37, 3 , 3 ,556.592
Set Internal Change=Bald Eagle      ,Loc Hav         ,38446.87, 3 , 3 ,556.111
Set Internal Change=Bald Eagle      ,Loc Hav         ,37962.54, 3 , 3 ,555.7786
Set Internal Change=Bald Eagle      ,Loc Hav         ,37385.23, 3 , 3 ,555.5574
Set Internal Change=Bald Eagle      ,Loc Hav         ,36769.88, 3 , 3 ,555.4688
Set Internal Change=Bald Eagle      ,Loc Hav         ,36663.76, 3 , 3 ,555.4252
Set Internal Change=Bald Eagle      ,Loc Hav         ,36339.56, 3 , 3 ,555.2635
Set Internal Change=Bald Eagle      ,Loc Hav         ,35648.50, 3 , 3 ,555.0388
Set Internal Change=Bald Eagle      ,Loc Hav         ,35072.37, 3 , 3 ,554.9326
Set Internal Change=Bald Eagle      ,Loc Hav         ,34098.93, 3 , 3 ,554.6814
Set Internal Change=Bald Eagle      ,Loc Hav         ,33498.68, 3 , 3 ,554.5473
Set Internal Change=Bald Eagle      ,Loc Hav         ,32195.47, 3 , 3 ,553.7654
Set Internal Change=Bald Eagle      ,Loc Hav         ,30878.12, 3 , 3 ,552.9017
Set Internal Change=Bald Eagle      ,Loc Hav         ,29563.77, 3 , 3 ,552.3541
Set Internal Change=Bald Eagle      ,Loc Hav         ,27226.40, 3 , 3 ,550.6818
Set Internal Change=Bald Eagle      ,Loc Hav         ,25960.70, 3 , 3 ,548.8346
Set Internal Change=Bald Eagle      ,Loc Hav         ,24843.25, 3 , 3 ,547.6979
Set Internal Change=Bald Eagle      ,Loc Hav         ,24417.73, 3 , 3 ,547.515
Set Internal Change=Bald Eagle      ,Loc Hav         ,23872.06, 3 , 3 ,546.7274
Set Internal Change=Bald Eagle      ,Loc Hav         ,23783.65, 3 , 3 ,546.7003
Set Internal Change=Bald Eagle      ,Loc Hav         ,23384.79, 3 , 3 ,546.524
Set Internal Change=Bald Eagle      ,Loc Hav         ,22982.97, 3 , 3 ,546.1083
Set Internal Change=Bald Eagle      ,Loc Hav         ,22386.15, 3 , 3 ,545.4545
Set Internal Change=Bald Eagle      ,Loc Hav         ,21283.34, 3 , 3 ,544.9957
Set Internal Change=Bald Eagle      ,Loc Hav         ,21199.93, 3 , 3 ,544.9896
Set Internal Change=Bald Eagle      ,Loc Hav         ,20127.30, 3 , 3 ,544.817
Set Internal Change=Bald Eagle      ,Loc Hav         ,19036.24, 3 , 3 ,543.1188
Set Internal Change=Bald Eagle      ,Loc Hav         ,18200.10, 3 , 3 ,541.8532
Set Internal Change=Bald Eagle      ,Loc Hav         ,17549.23, 3 , 3 ,541.6595
Set Internal Change=Bald Eagle      ,Loc Hav         ,16787.45, 3 , 3 ,541.5056
Set Internal Change=Bald Eagle      ,Loc Hav         ,15407.88, 3 , 3 ,541.0692
Set Internal Change=Bald Eagle      ,Loc Hav         ,14814.34, 3 , 3 ,540.7071
Set Internal Change=Bald Eagle      ,Loc Hav         ,13326.74, 3 , 3 ,540.1532
Set Internal Change=Bald Eagle      ,Loc Hav         ,12035.22, 3 , 3 ,539.8902
Set Internal Change=Bald Eagle      ,Loc Hav         ,11865.80, 3 , 3 ,539.8637
Set Internal Change=Bald Eagle      ,Loc Hav         ,11116.44, 3 , 3 ,539.4345
Set Internal Change=Bald Eagle      ,Loc Hav         ,10995.73, 3 , 3 ,539.3231
Set Internal Change=Bald Eagle      ,Loc Hav         ,10221.14, 3 , 3 ,538.425
Set Internal Change=Bald Eagle      ,Loc Hav         ,9258.941, 3 , 3 ,537.685
Set Internal Change=Bald Eagle      ,Loc Hav         ,8541.462, 3 , 3 ,537.4908
Set Internal Change=Bald Eagle      ,Loc Hav         ,7936.130, 3 , 3 ,537.3242
Set Internal Change=Bald Eagle      ,Loc Hav         ,6940.066, 3 , 3 ,536.832
Set Internal Change=Bald Eagle      ,Loc Hav         ,6267.489, 3 , 3 ,536.4855
Set Internal Change=Bald Eagle      ,Loc Hav         ,5523.234, 3 , 3 ,536.2285
Set Internal Change=Bald Eagle      ,Loc Hav         ,4293.710, 3 , 3 ,535.7355
Set Internal Change=Bald Eagle      ,Loc Hav         ,3047.378, 3 , 3 ,534.969
Set Internal Change=Bald Eagle      ,Loc Hav         ,2731.142, 3 , 3 ,534.3834
Set Internal Change=Bald Eagle      ,Loc Hav         ,2501.017, 3 , 3 ,534.1808
Set Internal Change=Bald Eagle      ,Loc Hav         ,2371.827, 3 , 3 ,534.0215
Set Internal Change=Bald Eagle      ,Loc Hav         ,1692.633, 3 , 3 ,533.7507
Set Internal Change=Bald Eagle      ,Loc Hav         ,1212.855, 3 , 3 ,533.6479
Set Internal Change=Bald Eagle      ,Loc Hav         ,659.942 , 3 , 3 ,532.7947
Set Internal Change=Bald Eagle      ,Loc Hav         ,138154.4, 4 , 3 ,663.1459
Set Internal Change=Bald Eagle      ,Loc Hav         ,137690.8, 4 , 3 ,662.6369
Set Internal Change=Bald Eagle      ,Loc Hav         ,137327.0, 4 , 3 ,662.2448
Set Internal Change=Bald Eagle      ,Loc Hav         ,136564.9, 4 , 3 ,660.1179
Set Internal Change=Bald Eagle      ,Loc Hav         ,136202.3, 4 , 3 ,659.4015
Set Internal Change=Bald Eagle      ,Loc Hav         ,135591.4, 4 , 3 ,658.4263
Set Internal Change=Bald Eagle      ,Loc Hav         ,135068.7, 4 , 3 ,657.7131
Set Internal Change=Bald Eagle      ,Loc Hav         ,134487.2, 4 , 3 ,656.4459
Set Internal Change=Bald Eagle      ,Loc Hav         ,133881.0, 4 , 3 ,655.5137
Set Internal Change=Bald Eagle      ,Loc Hav         ,133446.1, 4 , 3 ,654.957
Set Internal Change=Bald Eagle      ,Loc Hav         ,132973.6, 4 , 3 ,654.3223
Set Internal Change=Bald Eagle      ,Loc Hav         ,132363.8, 4 , 3 ,653.4998
Set Internal Change=Bald Eagle      ,Loc Hav         ,131699.7, 4 , 3 ,652.0449
Set Internal Change=Bald Eagle      ,Loc Hav         ,130997.6, 4 , 3 ,650.2272
Set Internal Change=Bald Eagle      ,Loc Hav         ,130339.2, 4 , 3 ,648.9881
Set Internal Change=Bald Eagle      ,Loc Hav         ,129627.5, 4 , 3 ,648.0699
Set Internal Change=Bald Eagle      ,Loc Hav         ,128760.7, 4 , 3 ,646.132
Set Internal Change=Bald Eagle      ,Loc Hav         ,128280.7, 4 , 3 ,644.8767
Set Internal Change=Bald Eagle      ,Loc Hav         ,127410.9, 4 , 3 ,643.3398
Set Internal Change=Bald Eagle      ,Loc Hav         ,126741.0, 4 , 3 ,642.3021
Set Internal Change=Bald Eagle      ,Loc Hav         ,126454.1, 4 , 3 ,641.77
Set Internal Change=Bald Eagle      ,Loc Hav         ,126062.6, 4 , 3 ,641.146
Set Internal Change=Bald Eagle      ,Loc Hav         ,125704.7, 4 , 3 ,640.6179
Set Internal Change=Bald Eagle      ,Loc Hav         ,125091.9, 4 , 3 ,639.6945
Set Internal Change=Bald Eagle      ,Loc Hav         ,124615.5, 4 , 3 ,639.2657
Set Internal Change=Bald Eagle      ,Loc Hav         ,124025.0, 4 , 3 ,637.9625
Set Internal Change=Bald Eagle      ,Loc Hav         ,123503.5, 4 , 3 ,636.4839
Set Internal Change=Bald Eagle      ,Loc Hav         ,123123.6, 4 , 3 ,635.7029
Set Internal Change=Bald Eagle      ,Loc Hav         ,122703.3, 4 , 3 ,635.1271
Set Internal Change=Bald Eagle      ,Loc Hav         ,122190.8, 4 , 3 ,634.1422
Set Internal Change=Bald Eagle      ,Loc Hav         ,121754.0, 4 , 3 ,633.5466
Set Internal Change=Bald Eagle      ,Loc Hav         ,121394.1, 4 , 3 ,633.2667
Set Internal Change=Bald Eagle      ,Loc Hav         ,120862.6, 4 , 3 ,632.6574
Set Internal Change=Bald Eagle      ,Loc Hav         ,120421.4, 4 , 3 ,632.0256
Set Internal Change=Bald Eagle      ,Loc Hav         ,119954.9, 4 , 3 ,631.6016
Set Internal Change=Bald Eagle      ,Loc Hav         ,119473.8, 4 , 3 ,630.8211
Set Internal Change=Bald Eagle      ,Loc Hav         ,118901.0, 4 , 3 ,628.9855
Set Internal Change=Bald Eagle      ,Loc Hav         ,118300.5, 4 , 3 ,627.865
Set Internal Change=Bald Eagle      ,Loc Hav         ,117753.9, 4 , 3 ,627.6358
Set Internal Change=Bald Eagle      ,Loc Hav         ,117180.8, 4 , 3 ,627.4226
Set Internal Change=Bald Eagle      ,Loc Hav         ,116401.3, 4 , 3 ,627.0778
Set Internal Change=Bald Eagle      ,Loc Hav         ,115584.2, 4 , 3 ,626.3871
Set Internal Change=Bald Eagle      ,Loc Hav         ,114899.8, 4 , 3 ,625.4792
Set Internal Change=Bald Eagle      ,Loc Hav         ,113985.6, 4 , 3 ,624.4897
Set Internal Change=Bald Eagle      ,Loc Hav         ,112856.9, 4 , 3 ,623.9166
Set Internal Change=Bald Eagle      ,Loc Hav         ,111971.0, 4 , 3 ,622.547
Set Internal Change=Bald Eagle      ,Loc Hav         ,110657.4, 4 , 3 ,620.4211
Set Internal Change=Bald Eagle      ,Loc Hav         ,109659.9, 4 , 3 ,619.4858
Set Internal Change=Bald Eagle      ,Loc Hav         ,108600.1, 4 , 3 ,618.7391
Set Internal Change=Bald Eagle      ,Loc Hav         ,107333.6, 4 , 3 ,617.259
Set Internal Change=Bald Eagle      ,Loc Hav         ,106466.0, 4 , 3 ,616.1182
Set Internal Change=Bald Eagle      ,Loc Hav         ,105178.6, 4 , 3 ,615.5127
Set Internal Change=Bald Eagle      ,Loc Hav         ,104647.2, 4 , 3 ,614.9007
Set Internal Change=Bald Eagle      ,Loc Hav         ,104195.0, 4 , 3 ,614.4514
Set Internal Change=Bald Eagle      ,Loc Hav         ,103854.0, 4 , 3 ,614.384
Set Internal Change=Bald Eagle      ,Loc Hav         ,103369.7, 4 , 3 ,614.3192
Set Internal Change=Bald Eagle      ,Loc Hav         ,103122.3, 4 , 3 ,614.1913
Set Internal Change=Bald Eagle      ,Loc Hav         ,101440.3, 4 , 3 ,611.856
Set Internal Change=Bald Eagle      ,Loc Hav         ,100657.3, 4 , 3 ,610.784
Set Internal Change=Bald Eagle      ,Loc Hav         ,99452.75, 4 , 3 ,610.1891
Set Internal Change=Bald Eagle      ,Loc Hav         ,98206.87, 4 , 3 ,609.5754
Set Internal Change=Bald Eagle      ,Loc Hav         ,97607.35, 4 , 3 ,608.6158
Set Internal Change=Bald Eagle      ,Loc Hav         ,96370.43, 4 , 3 ,605.9946
Set Internal Change=Bald Eagle      ,Loc Hav         ,94560.01, 4 , 3 ,603.278
Set Internal Change=Bald Eagle      ,Loc Hav         ,93391.71, 4 , 3 ,601.7408
Set Internal Change=Bald Eagle      ,Loc Hav         ,92011.85, 4 , 3 ,600.5695
Set Internal Change=Bald Eagle      ,Loc Hav         ,91030.01, 4 , 3 ,599.3278
Set Internal Change=Bald Eagle      ,Loc Hav         ,90096.99, 4 , 3 ,598.1015
Set Internal Change=Bald Eagle      ,Loc Hav         ,89060.69, 4 , 3 ,597.6641
Set Internal Change=Bald Eagle      ,Loc Hav         ,87861.14, 4 , 3 ,597.3593
Set Internal Change=Bald Eagle      ,Loc Hav         ,86942.04, 4 , 3 ,597.2878
Set Internal Change=Bald Eagle      ,Loc Hav         ,85569.53, 4 , 3 ,597.2748
Set Internal Change=Bald Eagle      ,Loc Hav         ,84724.08, 4 , 3 ,597.2709
Set Internal Change=Bald Eagle      ,Loc Hav         ,83563.41, 4 , 3 ,597.2689
Set Internal Change=Bald Eagle      ,Loc Hav         ,82607.89, 4 , 3 ,597.2682
Set Internal Change=Bald Eagle      ,Loc Hav         ,81849.41, 4 , 3 ,596.4365
Set Internal Change=Bald Eagle      ,Loc Hav         ,81084.18, 4 , 3 ,587.4639
Set Internal Change=Bald Eagle      ,Loc Hav         ,80500.50, 4 , 3 ,585.9579
Set Internal Change=Bald Eagle      ,Loc Hav         ,79684.28, 4 , 3 ,585.4959
Set Internal Change=Bald Eagle      ,Loc Hav         ,78627.87, 4 , 3 ,585.2784
Set Internal Change=Bald Eagle      ,Loc Hav         ,76643.40, 4 , 3 ,583.6602
Set Internal Change=Bald Eagle      ,Loc Hav         ,76002.96, 4 , 3 ,582.6567
Set Internal Change=Bald Eagle      ,Loc Hav         ,75917.82, 4 , 3 ,582.4318
Set Internal Change=Bald Eagle      ,Loc Hav         ,75616.14, 4 , 3 ,581.9183
Set Internal Change=Bald Eagle      ,Loc Hav         ,74650.60, 4 , 3 ,581.1604
Set Internal Change=Bald Eagle      ,Loc Hav         ,74207.96, 4 , 3 ,580.8436
Set Internal Change=Bald Eagle      ,Loc Hav         ,73504.24, 4 , 3 ,580.1523
Set Internal Change=Bald Eagle      ,Loc Hav         ,72303.68, 4 , 3 ,578.963
Set Internal Change=Bald Eagle      ,Loc Hav         ,71400.81, 4 , 3 ,578.044
Set Internal Change=Bald Eagle      ,Loc Hav         ,70651.52, 4 , 3 ,577.3481
Set Internal Change=Bald Eagle      ,Loc Hav         ,69567.33, 4 , 3 ,576.5922
Set Internal Change=Bald Eagle      ,Loc Hav         ,68604.09, 4 , 3 ,576.1177
Set Internal Change=Bald Eagle      ,Loc Hav         ,67326.78, 4 , 3 ,575.5913
Set Internal Change=Bald Eagle      ,Loc Hav         ,66070.17, 4 , 3 ,574.7128
Set Internal Change=Bald Eagle      ,Loc Hav         ,64908.02, 4 , 3 ,573.531
Set Internal Change=Bald Eagle      ,Loc Hav         ,63812.99, 4 , 3 ,572.4073
Set Internal Change=Bald Eagle      ,Loc Hav         ,62746.41, 4 , 3 ,571.3571
Set Internal Change=Bald Eagle      ,Loc Hav         ,61896.89, 4 , 3 ,570.4341
Set Internal Change=Bald Eagle      ,Loc Hav         ,60901.09, 4 , 3 ,569.2878
Set Internal Change=Bald Eagle      ,Loc Hav         ,59795.28, 4 , 3 ,568.0502
Set Internal Change=Bald Eagle      ,Loc Hav         ,58836.23, 4 , 3 ,567.3567
Set Internal Change=Bald Eagle      ,Loc Hav         ,58708.54, 4 , 3 ,567.283
Set Internal Change=Bald Eagle      ,Loc Hav         ,58091.91, 4 , 3 ,566.8593
Set Internal Change=Bald Eagle      ,Loc Hav         ,57700.27, 4 , 3 ,566.5302
Set Internal Change=Bald Eagle      ,Loc Hav         ,57250.60, 4 , 3 ,566.248
Set Internal Change=Bald Eagle      ,Loc Hav         ,56775.92, 4 , 3 ,565.8787
Set Internal Change=Bald Eagle      ,Loc Hav         ,56243.79, 4 , 3 ,565.4347
Set Internal Change=Bald Eagle      ,Loc Hav         ,55700.55, 4 , 3 ,564.9769
Set Internal Change=Bald Eagle      ,Loc Hav         ,54696.51, 4 , 3 ,564.2365
Set Internal Change=Bald Eagle      ,Loc Hav         ,53922.53, 4 , 3 ,563.7926
Set Internal Change=Bald Eagle      ,Loc Hav         ,52879.19, 4 , 3 ,563.3509
Set Internal Change=Bald Eagle      ,Loc Hav         ,51784.74, 4 , 3 ,563.0035
Set Internal Change=Bald Eagle      ,Loc Hav         ,50720.68, 4 , 3 ,562.7916
Set Internal Change=Bald Eagle      ,Loc Hav         ,49715.77, 4 , 3 ,562.4958
Set Internal Change=Bald Eagle      ,Loc Hav         ,48965.94, 4 , 3 ,562.218
Set Internal Change=Bald Eagle      ,Loc Hav         ,48110.09, 4 , 3 ,561.4196
Set Internal Change=Bald Eagle      ,Loc Hav         ,47453.14, 4 , 3 ,560.7661
Set Internal Change=Bald Eagle      ,Loc Hav         ,46722.59, 4 , 3 ,560.1738
Set Internal Change=Bald Eagle      ,Loc Hav         ,46310.48, 4 , 3 ,559.9157
Set Internal Change=Bald Eagle      ,Loc Hav         ,45805.37, 4 , 3 ,559.7285
Set Internal Change=Bald Eagle      ,Loc Hav         ,45233.89, 4 , 3 ,559.5765
Set Internal Change=Bald Eagle      ,Loc Hav         ,44529.29, 4 , 3 ,559.3363
Set Internal Change=Bald Eagle      ,Loc Hav         ,43919.30, 4 , 3 ,559.1223
Set Internal Change=Bald Eagle      ,Loc Hav         ,42895.87, 4 , 3 ,558.4915
Set Internal Change=Bald Eagle      ,Loc Hav         ,41806.43, 4 , 3 ,557.7269
Set Internal Change=Bald Eagle      ,Loc Hav         ,40526.85, 4 , 3 ,557.0052
Set Internal Change=Bald Eagle      ,Loc Hav         ,39499.37, 4 , 3 ,556.6442
Set Internal Change=Bald Eagle      ,Loc Hav         ,38446.87, 4 , 3 ,556.1659
Set Internal Change=Bald Eagle      ,Loc Hav         ,37962.54, 4 , 3 ,555.8354
Set Internal Change=Bald Eagle      ,Loc Hav         ,37385.23, 4 , 3 ,555.6149
Set Internal Change=Bald Eagle      ,Loc Hav         ,36769.88, 4 , 3 ,555.5257
Set Internal Change=Bald Eagle      ,Loc Hav         ,36663.76, 4 , 3 ,555.4818
Set Internal Change=Bald Eagle      ,Loc Hav         ,36339.56, 4 , 3 ,555.318
Set Internal Change=Bald Eagle      ,Loc Hav         ,35648.50, 4 , 3 ,555.0916
Set Internal Change=Bald Eagle      ,Loc Hav         ,35072.37, 4 , 3 ,554.9843
Set Internal Change=Bald Eagle      ,Loc Hav         ,34098.93, 4 , 3 ,554.7339
Set Internal Change=Bald Eagle      ,Loc Hav         ,33498.68, 4 , 3 ,554.5997
Set Internal Change=Bald Eagle      ,Loc Hav         ,32195.47, 4 , 3 ,553.8143
Set Internal Change=Bald Eagle      ,Loc Hav         ,30878.12, 4 , 3 ,552.9491
Set Internal Change=Bald Eagle      ,Loc Hav         ,29563.77, 4 , 3 ,552.401
Set Internal Change=Bald Eagle      ,Loc Hav         ,27226.40, 4 , 3 ,550.7142
Set Internal Change=Bald Eagle      ,Loc Hav         ,25960.70, 4 , 3 ,548.8547
Set Internal Change=Bald Eagle      ,Loc Hav         ,24843.25, 4 , 3 ,547.7128
Set Internal Change=Bald Eagle      ,Loc Hav         ,24417.73, 4 , 3 ,547.53
Set Internal Change=Bald Eagle      ,Loc Hav         ,23872.06, 4 , 3 ,546.738
Set Internal Change=Bald Eagle      ,Loc Hav         ,23783.65, 4 , 3 ,546.7106
Set Internal Change=Bald Eagle      ,Loc Hav         ,23384.79, 4 , 3 ,546.5327
Set Internal Change=Bald Eagle      ,Loc Hav         ,22982.97, 4 , 3 ,546.119
Set Internal Change=Bald Eagle      ,Loc Hav         ,22386.15, 4 , 3 ,545.4684
Set Internal Change=Bald Eagle      ,Loc Hav         ,21283.34, 4 , 3 ,545.0089
Set Internal Change=Bald Eagle      ,Loc Hav         ,21199.93, 4 , 3 ,545.0029
Set Internal Change=Bald Eagle      ,Loc Hav         ,20127.30, 4 , 3 ,544.8292
Set Internal Change=Bald Eagle      ,Loc Hav         ,19036.24, 4 , 3 ,543.1285
Set Internal Change=Bald Eagle      ,Loc Hav         ,18200.10, 4 , 3 ,541.8616
Set Internal Change=Bald Eagle      ,Loc Hav         ,17549.23, 4 , 3 ,541.6674
Set Internal Change=Bald Eagle      ,Loc Hav         ,16787.45, 4 , 3 ,541.5131
Set Internal Change=Bald Eagle      ,Loc Hav         ,15407.88, 4 , 3 ,541.0756
Set Internal Change=Bald Eagle      ,Loc Hav         ,14814.34, 4 , 3 ,540.7125
Set Internal Change=Bald Eagle      ,Loc Hav         ,13326.74, 4 , 3 ,540.1572
Set Internal Change=Bald Eagle      ,Loc Hav         ,12035.22, 4 , 3 ,539.8936
Set Internal Change=Bald Eagle      ,Loc Hav         ,11865.80, 4 , 3 ,539.8669
Set Internal Change=Bald Eagle      ,Loc Hav         ,11116.44, 4 , 3 ,539.4374
Set Internal Change=Bald Eagle      ,Loc Hav         ,10995.73, 4 , 3 ,539.326
Set Internal Change=Bald Eagle      ,Loc Hav         ,10221.14, 4 , 3 ,538.428
Set Internal Change=Bald Eagle      ,Loc Hav         ,9258.941, 4 , 3 ,537.688
Set Internal Change=Bald Eagle      ,Loc Hav         ,8541.462, 4 , 3 ,537.4937
Set Internal Change=Bald Eagle      ,Loc Hav         ,7936.130, 4 , 3 ,537.3268
Set Internal Change=Bald Eagle      ,Loc Hav         ,6940.066, 4 , 3 ,536.8345
Set Internal Change=Bald Eagle      ,Loc Hav         ,6267.489, 4 , 3 ,536.4879
Set Internal Change=Bald Eagle      ,Loc Hav         ,5523.234, 4 , 3 ,536.2307
Set Internal Change=Bald Eagle      ,Loc Hav         ,4293.710, 4 , 3 ,535.7374
Set Internal Change=Bald Eagle      ,Loc Hav         ,3047.378, 4 , 3 ,534.9707
Set Internal Change=Bald Eagle      ,Loc Hav         ,2731.142, 4 , 3 ,534.3846
Set Internal Change=Bald Eagle      ,Loc Hav         ,2501.017, 4 , 3 ,534.1819
Set Internal Change=Bald Eagle      ,Loc Hav         ,2371.827, 4 , 3 ,534.0227
Set Internal Change=Bald Eagle      ,Loc Hav         ,1692.633, 4 , 3 ,533.7516
Set Internal Change=Bald Eagle      ,Loc Hav         ,1212.855, 4 , 3 ,533.6487
Set Internal Change=Bald Eagle      ,Loc Hav         ,659.942 , 4 , 3 ,532.7972
Set Internal Change=Bald Eagle      ,Loc Hav         ,138154.4, 5 , 3 ,664.1744
Set Internal Change=Bald Eagle      ,Loc Hav         ,137690.8, 5 , 3 ,663.7023
Set Internal Change=Bald Eagle      ,Loc Hav         ,137327.0, 5 , 3 ,663.306
Set Internal Change=Bald Eagle      ,Loc Hav         ,136564.9, 5 , 3 ,661.0667
Set Internal Change=Bald Eagle      ,Loc Hav         ,136202.3, 5 , 3 ,660.366
Set Internal Change=Bald Eagle      ,Loc Hav         ,135591.4, 5 , 3 ,659.2839
Set Internal Change=Bald Eagle      ,Loc Hav         ,135068.7, 5 , 3 ,658.5703
Set Internal Change=Bald Eagle      ,Loc Hav         ,134487.2, 5 , 3 ,657.4128
Set Internal Change=Bald Eagle      ,Loc Hav         ,133881.0, 5 , 3 ,656.553
Set Internal Change=Bald Eagle      ,Loc Hav         ,133446.1, 5 , 3 ,656.0433
Set Internal Change=Bald Eagle      ,Loc Hav         ,132973.6, 5 , 3 ,655.4669
Set Internal Change=Bald Eagle      ,Loc Hav         ,132363.8, 5 , 3 ,654.5635
Set Internal Change=Bald Eagle      ,Loc Hav         ,131699.7, 5 , 3 ,652.9177
Set Internal Change=Bald Eagle      ,Loc Hav         ,130997.6, 5 , 3 ,651.0933
Set Internal Change=Bald Eagle      ,Loc Hav         ,130339.2, 5 , 3 ,649.7583
Set Internal Change=Bald Eagle      ,Loc Hav         ,129627.5, 5 , 3 ,648.5298
Set Internal Change=Bald Eagle      ,Loc Hav         ,128760.7, 5 , 3 ,646.6902
Set Internal Change=Bald Eagle      ,Loc Hav         ,128280.7, 5 , 3 ,645.637
Set Internal Change=Bald Eagle      ,Loc Hav         ,127410.9, 5 , 3 ,644.2172
Set Internal Change=Bald Eagle      ,Loc Hav         ,126741.0, 5 , 3 ,643.2564
Set Internal Change=Bald Eagle      ,Loc Hav         ,126454.1, 5 , 3 ,642.7466
Set Internal Change=Bald Eagle      ,Loc Hav         ,126062.6, 5 , 3 ,642.1052
Set Internal Change=Bald Eagle      ,Loc Hav         ,125704.7, 5 , 3 ,641.5643
Set Internal Change=Bald Eagle      ,Loc Hav         ,125091.9, 5 , 3 ,640.7518
Set Internal Change=Bald Eagle      ,Loc Hav         ,124615.5, 5 , 3 ,640.3721
Set Internal Change=Bald Eagle      ,Loc Hav         ,124025.0, 5 , 3 ,638.9761
Set Internal Change=Bald Eagle      ,Loc Hav         ,123503.5, 5 , 3 ,637.624
Set Internal Change=Bald Eagle      ,Loc Hav         ,123123.6, 5 , 3 ,636.8331
Set Internal Change=Bald Eagle      ,Loc Hav         ,122703.3, 5 , 3 ,636.1963
Set Internal Change=Bald Eagle      ,Loc Hav         ,122190.8, 5 , 3 ,635.3682
Set Internal Change=Bald Eagle      ,Loc Hav         ,121754.0, 5 , 3 ,634.8287
Set Internal Change=Bald Eagle      ,Loc Hav         ,121394.1, 5 , 3 ,634.5195
Set Internal Change=Bald Eagle      ,Loc Hav         ,120862.6, 5 , 3 ,633.9477
Set Internal Change=Bald Eagle      ,Loc Hav         ,120421.4, 5 , 3 ,633.3157
Set Internal Change=Bald Eagle      ,Loc Hav         ,119954.9, 5 , 3 ,632.8148
Set Internal Change=Bald Eagle      ,Loc Hav         ,119473.8, 5 , 3 ,632.0385
Set Internal Change=Bald Eagle      ,Loc Hav         ,118901.0, 5 , 3 ,630.4766
Set Internal Change=Bald Eagle      ,Loc Hav         ,118300.5, 5 , 3 ,629.4944
Set Internal Change=Bald Eagle      ,Loc Hav         ,117753.9, 5 , 3 ,629.2232
Set Internal Change=Bald Eagle      ,Loc Hav         ,117180.8, 5 , 3 ,628.885
Set Internal Change=Bald Eagle      ,Loc Hav         ,116401.3, 5 , 3 ,628.2543
Set Internal Change=Bald Eagle      ,Loc Hav         ,115584.2, 5 , 3 ,627.5441
Set Internal Change=Bald Eagle      ,Loc Hav         ,114899.8, 5 , 3 ,626.5934
Set Internal Change=Bald Eagle      ,Loc Hav         ,113985.6, 5 , 3 ,625.3456
Set Internal Change=Bald Eagle      ,Loc Hav         ,112856.9, 5 , 3 ,624.5258
Set Internal Change=Bald Eagle      ,Loc Hav         ,111971.0, 5 , 3 ,623.3131
Set Internal Change=Bald Eagle      ,Loc Hav         ,110657.4, 5 , 3 ,621.6592
Set Internal Change=Bald Eagle      ,Loc Hav         ,109659.9, 5 , 3 ,620.851
Set Internal Change=Bald Eagle      ,Loc Hav         ,108600.1, 5 , 3 ,620.1949
Set Internal Change=Bald Eagle      ,Loc Hav         ,107333.6, 5 , 3 ,618.7126
Set Internal Change=Bald Eagle      ,Loc Hav         ,106466.0, 5 , 3 ,617.7047
Set Internal Change=Bald Eagle      ,Loc Hav         ,105178.6, 5 , 3 ,617.1641
Set Internal Change=Bald Eagle      ,Loc Hav         ,104647.2, 5 , 3 ,616.4745
Set Internal Change=Bald Eagle      ,Loc Hav         ,104195.0, 5 , 3 ,616.0129
Set Internal Change=Bald Eagle      ,Loc Hav         ,103854.0, 5 , 3 ,615.9047
Set Internal Change=Bald Eagle      ,Loc Hav         ,103369.7, 5 , 3 ,615.7614
Set Internal Change=Bald Eagle      ,Loc Hav         ,103122.3, 5 , 3 ,615.3624
Set Internal Change=Bald Eagle      ,Loc Hav         ,101440.3, 5 , 3 ,613.3406
Set Internal Change=Bald Eagle      ,Loc Hav         ,100657.3, 5 , 3 ,612.6088
Set Internal Change=Bald Eagle      ,Loc Hav         ,99452.75, 5 , 3 ,612.0315
Set Internal Change=Bald Eagle      ,Loc Hav         ,98206.87, 5 , 3 ,611.5011
Set Internal Change=Bald Eagle      ,Loc Hav         ,97607.35, 5 , 3 ,610.5115
Set Internal Change=Bald Eagle      ,Loc Hav         ,96370.43, 5 , 3 ,607.4162
Set Internal Change=Bald Eagle      ,Loc Hav         ,94560.01, 5 , 3 ,604.7573
Set Internal Change=Bald Eagle      ,Loc Hav         ,93391.71, 5 , 3 ,603.1934
Set Internal Change=Bald Eagle      ,Loc Hav         ,92011.85, 5 , 3 ,601.7563
Set Internal Change=Bald Eagle      ,Loc Hav         ,91030.01, 5 , 3 ,600.2347
Set Internal Change=Bald Eagle      ,Loc Hav         ,90096.99, 5 , 3 ,598.604
Set Internal Change=Bald Eagle      ,Loc Hav         ,89060.69, 5 , 3 ,597.9401
Set Internal Change=Bald Eagle      ,Loc Hav         ,87861.14, 5 , 3 ,597.4444
Set Internal Change=Bald Eagle      ,Loc Hav         ,86942.04, 5 , 3 ,597.3445
Set Internal Change=Bald Eagle      ,Loc Hav         ,85569.53, 5 , 3 ,597.3235
Set Internal Change=Bald Eagle      ,Loc Hav         ,84724.08, 5 , 3 ,597.3177
Set Internal Change=Bald Eagle      ,Loc Hav         ,83563.41, 5 , 3 ,597.3149
Set Internal Change=Bald Eagle      ,Loc Hav         ,82607.89, 5 , 3 ,597.3141
Set Internal Change=Bald Eagle      ,Loc Hav         ,81849.41, 5 , 3 ,596.4897
Set Internal Change=Bald Eagle      ,Loc Hav         ,81084.18, 5 , 3 ,587.4847
Set Internal Change=Bald Eagle      ,Loc Hav         ,80500.50, 5 , 3 ,585.9739
Set Internal Change=Bald Eagle      ,Loc Hav         ,79684.28, 5 , 3 ,585.5076
Set Internal Change=Bald Eagle      ,Loc Hav         ,78627.87, 5 , 3 ,585.2879
Set Internal Change=Bald Eagle      ,Loc Hav         ,76643.40, 5 , 3 ,583.6639
Set Internal Change=Bald Eagle      ,Loc Hav         ,76002.96, 5 , 3 ,582.6586
Set Internal Change=Bald Eagle      ,Loc Hav         ,75917.82, 5 , 3 ,582.4333
Set Internal Change=Bald Eagle      ,Loc Hav         ,75616.14, 5 , 3 ,581.9188
Set Internal Change=Bald Eagle      ,Loc Hav         ,74650.60, 5 , 3 ,581.1588
Set Internal Change=Bald Eagle      ,Loc Hav         ,74207.96, 5 , 3 ,580.8411
Set Internal Change=Bald Eagle      ,Loc Hav         ,73504.24, 5 , 3 ,580.1475
Set Internal Change=Bald Eagle      ,Loc Hav         ,72303.68, 5 , 3 ,578.9554
Set Internal Change=Bald Eagle      ,Loc Hav         ,71400.81, 5 , 3 ,578.0353
Set Internal Change=Bald Eagle      ,Loc Hav         ,70651.52, 5 , 3 ,577.3385
Set Internal Change=Bald Eagle      ,Loc Hav         ,69567.33, 5 , 3 ,576.5815
Set Internal Change=Bald Eagle      ,Loc Hav         ,68604.09, 5 , 3 ,576.1062
Set Internal Change=Bald Eagle      ,Loc Hav         ,67326.78, 5 , 3 ,575.5793
Set Internal Change=Bald Eagle      ,Loc Hav         ,66070.17, 5 , 3 ,574.7012
Set Internal Change=Bald Eagle      ,Loc Hav         ,64908.02, 5 , 3 ,573.5209
Set Internal Change=Bald Eagle      ,Loc Hav         ,63812.99, 5 , 3 ,572.3987
Set Internal Change=Bald Eagle      ,Loc Hav         ,62746.41, 5 , 3 ,571.3491
Set Internal Change=Bald Eagle      ,Loc Hav         ,61896.89, 5 , 3 ,570.4256
Set Internal Change=Bald Eagle      ,Loc Hav         ,60901.09, 5 , 3 ,569.2778
Set Internal Change=Bald Eagle      ,Loc Hav         ,59795.28, 5 , 3 ,568.0374
Set Internal Change=Bald Eagle      ,Loc Hav         ,58836.23, 5 , 3 ,567.3427
Set Internal Change=Bald Eagle      ,Loc Hav         ,58708.54, 5 , 3 ,567.269
Set Internal Change=Bald Eagle      ,Loc Hav         ,58091.91, 5 , 3 ,566.8461
Set Internal Change=Bald Eagle      ,Loc Hav         ,57700.27, 5 , 3 ,566.5178
Set Internal Change=Bald Eagle      ,Loc Hav         ,57250.60, 5 , 3 ,566.2355
Set Internal Change=Bald Eagle      ,Loc Hav         ,56775.92, 5 , 3 ,565.8665
Set Internal Change=Bald Eagle      ,Loc Hav         ,56243.79, 5 , 3 ,565.4225
Set Internal Change=Bald Eagle      ,Loc Hav         ,55700.55, 5 , 3 ,564.9638
Set Internal Change=Bald Eagle      ,Loc Hav         ,54696.51, 5 , 3 ,564.2217
Set Internal Change=Bald Eagle      ,Loc Hav         ,53922.53, 5 , 3 ,563.7785
Set Internal Change=Bald Eagle      ,Loc Hav         ,52879.19, 5 , 3 ,563.3384
Set Internal Change=Bald Eagle      ,Loc Hav         ,51784.74, 5 , 3 ,562.9925
Set Internal Change=Bald Eagle      ,Loc Hav         ,50720.68, 5 , 3 ,562.7816
Set Internal Change=Bald Eagle      ,Loc Hav         ,49715.77, 5 , 3 ,562.4867
Set Internal Change=Bald Eagle      ,Loc Hav         ,48965.94, 5 , 3 ,562.2096
Set Internal Change=Bald Eagle      ,Loc Hav         ,48110.09, 5 , 3 ,561.4124
Set Internal Change=Bald Eagle      ,Loc Hav         ,47453.14, 5 , 3 ,560.7598
Set Internal Change=Bald Eagle      ,Loc Hav         ,46722.59, 5 , 3 ,560.169
Set Internal Change=Bald Eagle      ,Loc Hav         ,46310.48, 5 , 3 ,559.9117
Set Internal Change=Bald Eagle      ,Loc Hav         ,45805.37, 5 , 3 ,559.7252
Set Internal Change=Bald Eagle      ,Loc Hav         ,45233.89, 5 , 3 ,559.5739
Set Internal Change=Bald Eagle      ,Loc Hav         ,44529.29, 5 , 3 ,559.3347
Set Internal Change=Bald Eagle      ,Loc Hav         ,43919.30, 5 , 3 ,559.1215
Set Internal Change=Bald Eagle      ,Loc Hav         ,42895.87, 5 , 3 ,558.4934
Set Internal Change=Bald Eagle      ,Loc Hav         ,41806.43, 5 , 3 ,557.7324
Set Internal Change=Bald Eagle      ,Loc Hav         ,40526.85, 5 , 3 ,557.018
Set Internal Change=Bald Eagle      ,Loc Hav         ,39499.37, 5 , 3 ,556.6611
Set Internal Change=Bald Eagle      ,Loc Hav         ,38446.87, 5 , 3 ,556.1889
Set Internal Change=Bald Eagle      ,Loc Hav         ,37962.54, 5 , 3 ,555.863
Set Internal Change=Bald Eagle      ,Loc Hav         ,37385.23, 5 , 3 ,555.6456
Set Internal Change=Bald Eagle      ,Loc Hav         ,36769.88, 5 , 3 ,555.5572
Set Internal Change=Bald Eagle      ,Loc Hav         ,36663.76, 5 , 3 ,555.5137
Set Internal Change=Bald Eagle      ,Loc Hav         ,36339.56, 5 , 3 ,555.3507
Set Internal Change=Bald Eagle      ,Loc Hav         ,35648.50, 5 , 3 ,555.1262
Set Internal Change=Bald Eagle      ,Loc Hav         ,35072.37, 5 , 3 ,555.0196
Set Internal Change=Bald Eagle      ,Loc Hav         ,34098.93, 5 , 3 ,554.7724
Set Internal Change=Bald Eagle      ,Loc Hav         ,33498.68, 5 , 3 ,554.6394
Set Internal Change=Bald Eagle      ,Loc Hav         ,32195.47, 5 , 3 ,553.8567
Set Internal Change=Bald Eagle      ,Loc Hav         ,30878.12, 5 , 3 ,552.9968
Set Internal Change=Bald Eagle      ,Loc Hav         ,29563.77, 5 , 3 ,552.4506
Set Internal Change=Bald Eagle      ,Loc Hav         ,27226.40, 5 , 3 ,550.7543
Set Internal Change=Bald Eagle      ,Loc Hav         ,25960.70, 5 , 3 ,548.8848
Set Internal Change=Bald Eagle      ,Loc Hav         ,24843.25, 5 , 3 ,547.7384
Set Internal Change=Bald Eagle      ,Loc Hav         ,24417.73, 5 , 3 ,547.5563
Set Internal Change=Bald Eagle      ,Loc Hav         ,23872.06, 5 , 3 ,546.7582
Set Internal Change=Bald Eagle      ,Loc Hav         ,23783.65, 5 , 3 ,546.7303
Set Internal Change=Bald Eagle      ,Loc Hav         ,23384.79, 5 , 3 ,546.5497
Set Internal Change=Bald Eagle      ,Loc Hav         ,22982.97, 5 , 3 ,546.1429
Set Internal Change=Bald Eagle      ,Loc Hav         ,22386.15, 5 , 3 ,545.5032
Set Internal Change=Bald Eagle      ,Loc Hav         ,21283.34, 5 , 3 ,545.0454
Set Internal Change=Bald Eagle      ,Loc Hav         ,21199.93, 5 , 3 ,545.0393
Set Internal Change=Bald Eagle      ,Loc Hav         ,20127.30, 5 , 3 ,544.8629
Set Internal Change=Bald Eagle      ,Loc Hav         ,19036.24, 5 , 3 ,543.162
Set Internal Change=Bald Eagle      ,Loc Hav         ,18200.10, 5 , 3 ,541.8973
Set Internal Change=Bald Eagle      ,Loc Hav         ,17549.23, 5 , 3 ,541.7034
Set Internal Change=Bald Eagle      ,Loc Hav         ,16787.45, 5 , 3 ,541.5483
Set Internal Change=Bald Eagle      ,Loc Hav         ,15407.88, 5 , 3 ,541.1082
Set Internal Change=Bald Eagle      ,Loc Hav         ,14814.34, 5 , 3 ,540.7418
Set Internal Change=Bald Eagle      ,Loc Hav         ,13326.74, 5 , 3 ,540.1827
Set Internal Change=Bald Eagle      ,Loc Hav         ,12035.22, 5 , 3 ,539.9154
Set Internal Change=Bald Eagle      ,Loc Hav         ,11865.80, 5 , 3 ,539.8885
Set Internal Change=Bald Eagle      ,Loc Hav         ,11116.44, 5 , 3 ,539.4576
Set Internal Change=Bald Eagle      ,Loc Hav         ,10995.73, 5 , 3 ,539.3466
Set Internal Change=Bald Eagle      ,Loc Hav         ,10221.14, 5 , 3 ,538.4522
Set Internal Change=Bald Eagle      ,Loc Hav         ,9258.941, 5 , 3 ,537.7147
Set Internal Change=Bald Eagle      ,Loc Hav         ,8541.462, 5 , 3 ,537.5197
Set Internal Change=Bald Eagle      ,Loc Hav         ,7936.130, 5 , 3 ,537.3516
Set Internal Change=Bald Eagle      ,Loc Hav         ,6940.066, 5 , 3 ,536.8595
Set Internal Change=Bald Eagle      ,Loc Hav         ,6267.489, 5 , 3 ,536.5137
Set Internal Change=Bald Eagle      ,Loc Hav         ,5523.234, 5 , 3 ,536.2557
Set Internal Change=Bald Eagle      ,Loc Hav         ,4293.710, 5 , 3 ,535.7606
Set Internal Change=Bald Eagle      ,Loc Hav         ,3047.378, 5 , 3 ,534.9913
Set Internal Change=Bald Eagle      ,Loc Hav         ,2731.142, 5 , 3 ,534.3989
Set Internal Change=Bald Eagle      ,Loc Hav         ,2501.017, 5 , 3 ,534.1953
Set Internal Change=Bald Eagle      ,Loc Hav         ,2371.827, 5 , 3 ,534.0352
Set Internal Change=Bald Eagle      ,Loc Hav         ,1692.633, 5 , 3 ,533.7632
Set Internal Change=Bald Eagle      ,Loc Hav         ,1212.855, 5 , 3 ,533.6593
Set Internal Change=Bald Eagle      ,Loc Hav         ,659.942 , 5 , 3 ,532.8276
Set Internal Change=Bald Eagle      ,Loc Hav         ,138154.4, 6 , 3 ,665.0954
Set Internal Change=Bald Eagle      ,Loc Hav         ,137690.8, 6 , 3 ,664.6368
Set Internal Change=Bald Eagle      ,Loc Hav         ,137327.0, 6 , 3 ,664.2216
Set Internal Change=Bald Eagle      ,Loc Hav         ,136564.9, 6 , 3 ,661.8305
Set Internal Change=Bald Eagle      ,Loc Hav         ,136202.3, 6 , 3 ,661.1577
Set Internal Change=Bald Eagle      ,Loc Hav         ,135591.4, 6 , 3 ,660.0644
Set Internal Change=Bald Eagle      ,Loc Hav         ,135068.7, 6 , 3 ,659.3419
Set Internal Change=Bald Eagle      ,Loc Hav         ,134487.2, 6 , 3 ,658.1512
Set Internal Change=Bald Eagle      ,Loc Hav         ,133881.0, 6 , 3 ,657.2949
Set Internal Change=Bald Eagle      ,Loc Hav         ,133446.1, 6 , 3 ,656.7929
Set Internal Change=Bald Eagle      ,Loc Hav         ,132973.6, 6 , 3 ,656.2197
Set Internal Change=Bald Eagle      ,Loc Hav         ,132363.8, 6 , 3 ,655.2241
Set Internal Change=Bald Eagle      ,Loc Hav         ,131699.7, 6 , 3 ,653.5839
Set Internal Change=Bald Eagle      ,Loc Hav         ,130997.6, 6 , 3 ,651.722
Set Internal Change=Bald Eagle      ,Loc Hav         ,130339.2, 6 , 3 ,650.3325
Set Internal Change=Bald Eagle      ,Loc Hav         ,129627.5, 6 , 3 ,649.049
Set Internal Change=Bald Eagle      ,Loc Hav         ,128760.7, 6 , 3 ,647.2076
Set Internal Change=Bald Eagle      ,Loc Hav         ,128280.7, 6 , 3 ,646.1985
Set Internal Change=Bald Eagle      ,Loc Hav         ,127410.9, 6 , 3 ,644.9402
Set Internal Change=Bald Eagle      ,Loc Hav         ,126741.0, 6 , 3 ,644.0926
Set Internal Change=Bald Eagle      ,Loc Hav         ,126454.1, 6 , 3 ,643.5643
Set Internal Change=Bald Eagle      ,Loc Hav         ,126062.6, 6 , 3 ,642.9254
Set Internal Change=Bald Eagle      ,Loc Hav         ,125704.7, 6 , 3 ,642.3705
Set Internal Change=Bald Eagle      ,Loc Hav         ,125091.9, 6 , 3 ,641.4676
Set Internal Change=Bald Eagle      ,Loc Hav         ,124615.5, 6 , 3 ,641.0337
Set Internal Change=Bald Eagle      ,Loc Hav         ,124025.0, 6 , 3 ,639.7516
Set Internal Change=Bald Eagle      ,Loc Hav         ,123503.5, 6 , 3 ,638.4894
Set Internal Change=Bald Eagle      ,Loc Hav         ,123123.6, 6 , 3 ,637.742
Set Internal Change=Bald Eagle      ,Loc Hav         ,122703.3, 6 , 3 ,637.1442
Set Internal Change=Bald Eagle      ,Loc Hav         ,122190.8, 6 , 3 ,636.3441
Set Internal Change=Bald Eagle      ,Loc Hav         ,121754.0, 6 , 3 ,635.8173
Set Internal Change=Bald Eagle      ,Loc Hav         ,121394.1, 6 , 3 ,635.5181
Set Internal Change=Bald Eagle      ,Loc Hav         ,120862.6, 6 , 3 ,634.9708
Set Internal Change=Bald Eagle      ,Loc Hav         ,120421.4, 6 , 3 ,634.2936
Set Internal Change=Bald Eagle      ,Loc Hav         ,119954.9, 6 , 3 ,633.7451
Set Internal Change=Bald Eagle      ,Loc Hav         ,119473.8, 6 , 3 ,632.8724
Set Internal Change=Bald Eagle      ,Loc Hav         ,118901.0, 6 , 3 ,631.3594
Set Internal Change=Bald Eagle      ,Loc Hav         ,118300.5, 6 , 3 ,630.4436
Set Internal Change=Bald Eagle      ,Loc Hav         ,117753.9, 6 , 3 ,630.0831
Set Internal Change=Bald Eagle      ,Loc Hav         ,117180.8, 6 , 3 ,629.5602
Set Internal Change=Bald Eagle      ,Loc Hav         ,116401.3, 6 , 3 ,628.8362
Set Internal Change=Bald Eagle      ,Loc Hav         ,115584.2, 6 , 3 ,628.1069
Set Internal Change=Bald Eagle      ,Loc Hav         ,114899.8, 6 , 3 ,627.2216
Set Internal Change=Bald Eagle      ,Loc Hav         ,113985.6, 6 , 3 ,626.0955
Set Internal Change=Bald Eagle      ,Loc Hav         ,112856.9, 6 , 3 ,625.2155
Set Internal Change=Bald Eagle      ,Loc Hav         ,111971.0, 6 , 3 ,624.1907
Set Internal Change=Bald Eagle      ,Loc Hav         ,110657.4, 6 , 3 ,622.7814
Set Internal Change=Bald Eagle      ,Loc Hav         ,109659.9, 6 , 3 ,622.034
Set Internal Change=Bald Eagle      ,Loc Hav         ,108600.1, 6 , 3 ,621.4331
Set Internal Change=Bald Eagle      ,Loc Hav         ,107333.6, 6 , 3 ,619.9628
Set Internal Change=Bald Eagle      ,Loc Hav         ,106466.0, 6 , 3 ,618.973
Set Internal Change=Bald Eagle      ,Loc Hav         ,105178.6, 6 , 3 ,618.3598
Set Internal Change=Bald Eagle      ,Loc Hav         ,104647.2, 6 , 3 ,617.8274
Set Internal Change=Bald Eagle      ,Loc Hav         ,104195.0, 6 , 3 ,617.4905
Set Internal Change=Bald Eagle      ,Loc Hav         ,103854.0, 6 , 3 ,617.3688
Set Internal Change=Bald Eagle      ,Loc Hav         ,103369.7, 6 , 3 ,617.1852
Set Internal Change=Bald Eagle      ,Loc Hav         ,103122.3, 6 , 3 ,616.6619
Set Internal Change=Bald Eagle      ,Loc Hav         ,101440.3, 6 , 3 ,614.6516
Set Internal Change=Bald Eagle      ,Loc Hav         ,100657.3, 6 , 3 ,613.8466
Set Internal Change=Bald Eagle      ,Loc Hav         ,99452.75, 6 , 3 ,613.1824
Set Internal Change=Bald Eagle      ,Loc Hav         ,98206.87, 6 , 3 ,612.6362
Set Internal Change=Bald Eagle      ,Loc Hav         ,97607.35, 6 , 3 ,611.5072
Set Internal Change=Bald Eagle      ,Loc Hav         ,96370.43, 6 , 3 ,608.6653
Set Internal Change=Bald Eagle      ,Loc Hav         ,94560.01, 6 , 3 ,605.988
Set Internal Change=Bald Eagle      ,Loc Hav         ,93391.71, 6 , 3 ,604.3989
Set Internal Change=Bald Eagle      ,Loc Hav         ,92011.85, 6 , 3 ,602.9889
Set Internal Change=Bald Eagle      ,Loc Hav         ,91030.01, 6 , 3 ,602.0354
Set Internal Change=Bald Eagle      ,Loc Hav         ,90096.99, 6 , 3 ,600.7188
Set Internal Change=Bald Eagle      ,Loc Hav         ,89060.69, 6 , 3 ,599.5629
Set Internal Change=Bald Eagle      ,Loc Hav         ,87861.14, 6 , 3 ,599.05
Set Internal Change=Bald Eagle      ,Loc Hav         ,86942.04, 6 , 3 ,598.9412
Set Internal Change=Bald Eagle      ,Loc Hav         ,85569.53, 6 , 3 ,598.8843
Set Internal Change=Bald Eagle      ,Loc Hav         ,84724.08, 6 , 3 ,598.8719
Set Internal Change=Bald Eagle      ,Loc Hav         ,83563.41, 6 , 3 ,598.8668
Set Internal Change=Bald Eagle      ,Loc Hav         ,82607.89, 6 , 3 ,598.8658
Set Internal Change=Bald Eagle      ,Loc Hav         ,81849.41, 6 , 3 ,598.1594
Set Internal Change=Bald Eagle      ,Loc Hav         ,81084.18, 6 , 3 ,588.2707
Set Internal Change=Bald Eagle      ,Loc Hav         ,80500.50, 6 , 3 ,586.7864
Set Internal Change=Bald Eagle      ,Loc Hav         ,79684.28, 6 , 3 ,586.2838
Set Internal Change=Bald Eagle      ,Loc Hav         ,78627.87, 6 , 3 ,586.0351
Set Internal Change=Bald Eagle      ,Loc Hav         ,76643.40, 6 , 3 ,584.0984
Set Internal Change=Bald Eagle      ,Loc Hav         ,76002.96, 6 , 3 ,583.1103
Set Internal Change=Bald Eagle      ,Loc Hav         ,75917.82, 6 , 3 ,582.9168
Set Internal Change=Bald Eagle      ,Loc Hav         ,75616.14, 6 , 3 ,582.4077
Set Internal Change=Bald Eagle      ,Loc Hav         ,74650.60, 6 , 3 ,581.5802
Set Internal Change=Bald Eagle      ,Loc Hav         ,74207.96, 6 , 3 ,581.2521
Set Internal Change=Bald Eagle      ,Loc Hav         ,73504.24, 6 , 3 ,580.5379
Set Internal Change=Bald Eagle      ,Loc Hav         ,72303.68, 6 , 3 ,579.3406
Set Internal Change=Bald Eagle      ,Loc Hav         ,71400.81, 6 , 3 ,578.3851
Set Internal Change=Bald Eagle      ,Loc Hav         ,70651.52, 6 , 3 ,577.6552
Set Internal Change=Bald Eagle      ,Loc Hav         ,69567.33, 6 , 3 ,576.8641
Set Internal Change=Bald Eagle      ,Loc Hav         ,68604.09, 6 , 3 ,576.3606
Set Internal Change=Bald Eagle      ,Loc Hav         ,67326.78, 6 , 3 ,575.8043
Set Internal Change=Bald Eagle      ,Loc Hav         ,66070.17, 6 , 3 ,574.8892
Set Internal Change=Bald Eagle      ,Loc Hav         ,64908.02, 6 , 3 ,573.6624
Set Internal Change=Bald Eagle      ,Loc Hav         ,63812.99, 6 , 3 ,572.5014
Set Internal Change=Bald Eagle      ,Loc Hav         ,62746.41, 6 , 3 ,571.4301
Set Internal Change=Bald Eagle      ,Loc Hav         ,61896.89, 6 , 3 ,570.4999
Set Internal Change=Bald Eagle      ,Loc Hav         ,60901.09, 6 , 3 ,569.3498
Set Internal Change=Bald Eagle      ,Loc Hav         ,59795.28, 6 , 3 ,568.1056
Set Internal Change=Bald Eagle      ,Loc Hav         ,58836.23, 6 , 3 ,567.4053
Set Internal Change=Bald Eagle      ,Loc Hav         ,58708.54, 6 , 3 ,567.3303
Set Internal Change=Bald Eagle      ,Loc Hav         ,58091.91, 6 , 3 ,566.8987
Set Internal Change=Bald Eagle      ,Loc Hav         ,57700.27, 6 , 3 ,566.5635
Set Internal Change=Bald Eagle      ,Loc Hav         ,57250.60, 6 , 3 ,566.2781
Set Internal Change=Bald Eagle      ,Loc Hav         ,56775.92, 6 , 3 ,565.9045
Set Internal Change=Bald Eagle      ,Loc Hav         ,56243.79, 6 , 3 ,565.4557
Set Internal Change=Bald Eagle      ,Loc Hav         ,55700.55, 6 , 3 ,564.9941
Set Internal Change=Bald Eagle      ,Loc Hav         ,54696.51, 6 , 3 ,564.2482
Set Internal Change=Bald Eagle      ,Loc Hav         ,53922.53, 6 , 3 ,563.8
Set Internal Change=Bald Eagle      ,Loc Hav         ,52879.19, 6 , 3 ,563.3541
Set Internal Change=Bald Eagle      ,Loc Hav         ,51784.74, 6 , 3 ,563.0037
Set Internal Change=Bald Eagle      ,Loc Hav         ,50720.68, 6 , 3 ,562.7903
Set Internal Change=Bald Eagle      ,Loc Hav         ,49715.77, 6 , 3 ,562.4933
Set Internal Change=Bald Eagle      ,Loc Hav         ,48965.94, 6 , 3 ,562.2148
Set Internal Change=Bald Eagle      ,Loc Hav         ,48110.09, 6 , 3 ,561.4151
Set Internal Change=Bald Eagle      ,Loc Hav         ,47453.14, 6 , 3 ,560.7605
Set Internal Change=Bald Eagle      ,Loc Hav         ,46722.59, 6 , 3 ,560.1674
Set Internal Change=Bald Eagle      ,Loc Hav         ,46310.48, 6 , 3 ,559.909
Set Internal Change=Bald Eagle      ,Loc Hav         ,45805.37, 6 , 3 ,559.7219
Set Internal Change=Bald Eagle      ,Loc Hav         ,45233.89, 6 , 3 ,559.5701
Set Internal Change=Bald Eagle      ,Loc Hav         ,44529.29, 6 , 3 ,559.3306
Set Internal Change=Bald Eagle      ,Loc Hav         ,43919.30, 6 , 3 ,559.1171
Set Internal Change=Bald Eagle      ,Loc Hav         ,42895.87, 6 , 3 ,558.4883
Set Internal Change=Bald Eagle      ,Loc Hav         ,41806.43, 6 , 3 ,557.7272
Set Internal Change=Bald Eagle      ,Loc Hav         ,40526.85, 6 , 3 ,557.0129
Set Internal Change=Bald Eagle      ,Loc Hav         ,39499.37, 6 , 3 ,556.6559
Set Internal Change=Bald Eagle      ,Loc Hav         ,38446.87, 6 , 3 ,556.1845
Set Internal Change=Bald Eagle      ,Loc Hav         ,37962.54, 6 , 3 ,555.8593
Set Internal Change=Bald Eagle      ,Loc Hav         ,37385.23, 6 , 3 ,555.6423
Set Internal Change=Bald Eagle      ,Loc Hav         ,36769.88, 6 , 3 ,555.5541
Set Internal Change=Bald Eagle      ,Loc Hav         ,36663.76, 6 , 3 ,555.5107
Set Internal Change=Bald Eagle      ,Loc Hav         ,36339.56, 6 , 3 ,555.3483
Set Internal Change=Bald Eagle      ,Loc Hav         ,35648.50, 6 , 3 ,555.1246
Set Internal Change=Bald Eagle      ,Loc Hav         ,35072.37, 6 , 3 ,555.0183
Set Internal Change=Bald Eagle      ,Loc Hav         ,34098.93, 6 , 3 ,554.7717
Set Internal Change=Bald Eagle      ,Loc Hav         ,33498.68, 6 , 3 ,554.639
Set Internal Change=Bald Eagle      ,Loc Hav         ,32195.47, 6 , 3 ,553.8578
Set Internal Change=Bald Eagle      ,Loc Hav         ,30878.12, 6 , 3 ,552.9998
Set Internal Change=Bald Eagle      ,Loc Hav         ,29563.77, 6 , 3 ,552.4545
Set Internal Change=Bald Eagle      ,Loc Hav         ,27226.40, 6 , 3 ,550.7599
Set Internal Change=Bald Eagle      ,Loc Hav         ,25960.70, 6 , 3 ,548.8909
Set Internal Change=Bald Eagle      ,Loc Hav         ,24843.25, 6 , 3 ,547.7447
Set Internal Change=Bald Eagle      ,Loc Hav         ,24417.73, 6 , 3 ,547.5627
Set Internal Change=Bald Eagle      ,Loc Hav         ,23872.06, 6 , 3 ,546.7637
Set Internal Change=Bald Eagle      ,Loc Hav         ,23783.65, 6 , 3 ,546.7357
Set Internal Change=Bald Eagle      ,Loc Hav         ,23384.79, 6 , 3 ,546.5546
Set Internal Change=Bald Eagle      ,Loc Hav         ,22982.97, 6 , 3 ,546.1506
Set Internal Change=Bald Eagle      ,Loc Hav         ,22386.15, 6 , 3 ,545.5155
Set Internal Change=Bald Eagle      ,Loc Hav         ,21283.34, 6 , 3 ,545.059
Set Internal Change=Bald Eagle      ,Loc Hav         ,21199.93, 6 , 3 ,545.0529
Set Internal Change=Bald Eagle      ,Loc Hav         ,20127.30, 6 , 3 ,544.8755
Set Internal Change=Bald Eagle      ,Loc Hav         ,19036.24, 6 , 3 ,543.179
Set Internal Change=Bald Eagle      ,Loc Hav         ,18200.10, 6 , 3 ,541.9197
Set Internal Change=Bald Eagle      ,Loc Hav         ,17549.23, 6 , 3 ,541.727
Set Internal Change=Bald Eagle      ,Loc Hav         ,16787.45, 6 , 3 ,541.5719
Set Internal Change=Bald Eagle      ,Loc Hav         ,15407.88, 6 , 3 ,541.131
Set Internal Change=Bald Eagle      ,Loc Hav         ,14814.34, 6 , 3 ,540.7636
Set Internal Change=Bald Eagle      ,Loc Hav         ,13326.74, 6 , 3 ,540.2035
Set Internal Change=Bald Eagle      ,Loc Hav         ,12035.22, 6 , 3 ,539.9342
Set Internal Change=Bald Eagle      ,Loc Hav         ,11865.80, 6 , 3 ,539.907
Set Internal Change=Bald Eagle      ,Loc Hav         ,11116.44, 6 , 3 ,539.4757
Set Internal Change=Bald Eagle      ,Loc Hav         ,10995.73, 6 , 3 ,539.3652
Set Internal Change=Bald Eagle      ,Loc Hav         ,10221.14, 6 , 3 ,538.478
Set Internal Change=Bald Eagle      ,Loc Hav         ,9258.941, 6 , 3 ,537.7474
Set Internal Change=Bald Eagle      ,Loc Hav         ,8541.462, 6 , 3 ,537.5527
Set Internal Change=Bald Eagle      ,Loc Hav         ,7936.130, 6 , 3 ,537.3842
Set Internal Change=Bald Eagle      ,Loc Hav         ,6940.066, 6 , 3 ,536.8956
Set Internal Change=Bald Eagle      ,Loc Hav         ,6267.489, 6 , 3 ,536.5529
Set Internal Change=Bald Eagle      ,Loc Hav         ,5523.234, 6 , 3 ,536.2952
Set Internal Change=Bald Eagle      ,Loc Hav         ,4293.710, 6 , 3 ,535.7988
Set Internal Change=Bald Eagle      ,Loc Hav         ,3047.378, 6 , 3 ,535.0262
Set Internal Change=Bald Eagle      ,Loc Hav         ,2731.142, 6 , 3 ,534.4233
Set Internal Change=Bald Eagle      ,Loc Hav         ,2501.017, 6 , 3 ,534.2184
Set Internal Change=Bald Eagle      ,Loc Hav         ,2371.827, 6 , 3 ,534.0585
Set Internal Change=Bald Eagle      ,Loc Hav         ,1692.633, 6 , 3 ,533.7887
Set Internal Change=Bald Eagle      ,Loc Hav         ,1212.855, 6 , 3 ,533.6831
Set Internal Change=Bald Eagle      ,Loc Hav         ,659.942 , 6 , 3 ,532.8869
Set Internal Change=Bald Eagle      ,Loc Hav         ,138154.4, 7 , 3 ,665.8752
Set Internal Change=Bald Eagle      ,Loc Hav         ,137690.8, 7 , 3 ,665.4498
Set Internal Change=Bald Eagle      ,Loc Hav         ,137327.0, 7 , 3 ,665.0424
Set Internal Change=Bald Eagle      ,Loc Hav         ,136564.9, 7 , 3 ,662.5199
Set Internal Change=Bald Eagle      ,Loc Hav         ,136202.3, 7 , 3 ,661.8499
Set Internal Change=Bald Eagle      ,Loc Hav         ,135591.4, 7 , 3 ,660.6708
Set Internal Change=Bald Eagle      ,Loc Hav         ,135068.7, 7 , 3 ,659.9373
Set Internal Change=Bald Eagle      ,Loc Hav         ,134487.2, 7 , 3 ,658.8163
Set Internal Change=Bald Eagle      ,Loc Hav         ,133881.0, 7 , 3 ,658.0259
Set Internal Change=Bald Eagle      ,Loc Hav         ,133446.1, 7 , 3 ,657.5231
Set Internal Change=Bald Eagle      ,Loc Hav         ,132973.6, 7 , 3 ,656.9478
Set Internal Change=Bald Eagle      ,Loc Hav         ,132363.8, 7 , 3 ,655.8749
Set Internal Change=Bald Eagle      ,Loc Hav         ,131699.7, 7 , 3 ,654.1623
Set Internal Change=Bald Eagle      ,Loc Hav         ,130997.6, 7 , 3 ,652.2745
Set Internal Change=Bald Eagle      ,Loc Hav         ,130339.2, 7 , 3 ,650.8962
Set Internal Change=Bald Eagle      ,Loc Hav         ,129627.5, 7 , 3 ,649.5692
Set Internal Change=Bald Eagle      ,Loc Hav         ,128760.7, 7 , 3 ,647.6209
Set Internal Change=Bald Eagle      ,Loc Hav         ,128280.7, 7 , 3 ,646.6464
Set Internal Change=Bald Eagle      ,Loc Hav         ,127410.9, 7 , 3 ,645.5523
Set Internal Change=Bald Eagle      ,Loc Hav         ,126741.0, 7 , 3 ,644.7668
Set Internal Change=Bald Eagle      ,Loc Hav         ,126454.1, 7 , 3 ,644.2233
Set Internal Change=Bald Eagle      ,Loc Hav         ,126062.6, 7 , 3 ,643.5565
Set Internal Change=Bald Eagle      ,Loc Hav         ,125704.7, 7 , 3 ,642.9962
Set Internal Change=Bald Eagle      ,Loc Hav         ,125091.9, 7 , 3 ,642.1039
Set Internal Change=Bald Eagle      ,Loc Hav         ,124615.5, 7 , 3 ,641.6647
Set Internal Change=Bald Eagle      ,Loc Hav         ,124025.0, 7 , 3 ,640.317
Set Internal Change=Bald Eagle      ,Loc Hav         ,123503.5, 7 , 3 ,639.1151
Set Internal Change=Bald Eagle      ,Loc Hav         ,123123.6, 7 , 3 ,638.4294
Set Internal Change=Bald Eagle      ,Loc Hav         ,122703.3, 7 , 3 ,637.8625
Set Internal Change=Bald Eagle      ,Loc Hav         ,122190.8, 7 , 3 ,637.1204
Set Internal Change=Bald Eagle      ,Loc Hav         ,121754.0, 7 , 3 ,636.6012
Set Internal Change=Bald Eagle      ,Loc Hav         ,121394.1, 7 , 3 ,636.2904
Set Internal Change=Bald Eagle      ,Loc Hav         ,120862.6, 7 , 3 ,635.7427
Set Internal Change=Bald Eagle      ,Loc Hav         ,120421.4, 7 , 3 ,635.0334
Set Internal Change=Bald Eagle      ,Loc Hav         ,119954.9, 7 , 3 ,634.4322
Set Internal Change=Bald Eagle      ,Loc Hav         ,119473.8, 7 , 3 ,633.5798
Set Internal Change=Bald Eagle      ,Loc Hav         ,118901.0, 7 , 3 ,632.1968
Set Internal Change=Bald Eagle      ,Loc Hav         ,118300.5, 7 , 3 ,631.2995
Set Internal Change=Bald Eagle      ,Loc Hav         ,117753.9, 7 , 3 ,630.8685
Set Internal Change=Bald Eagle      ,Loc Hav         ,117180.8, 7 , 3 ,630.1877
Set Internal Change=Bald Eagle      ,Loc Hav         ,116401.3, 7 , 3 ,629.3837
Set Internal Change=Bald Eagle      ,Loc Hav         ,115584.2, 7 , 3 ,628.6456
Set Internal Change=Bald Eagle      ,Loc Hav         ,114899.8, 7 , 3 ,627.7563
Set Internal Change=Bald Eagle      ,Loc Hav         ,113985.6, 7 , 3 ,626.6553
Set Internal Change=Bald Eagle      ,Loc Hav         ,112856.9, 7 , 3 ,625.7177
Set Internal Change=Bald Eagle      ,Loc Hav         ,111971.0, 7 , 3 ,624.7855
Set Internal Change=Bald Eagle      ,Loc Hav         ,110657.4, 7 , 3 ,623.5859
Set Internal Change=Bald Eagle      ,Loc Hav         ,109659.9, 7 , 3 ,622.792
Set Internal Change=Bald Eagle      ,Loc Hav         ,108600.1, 7 , 3 ,622.079
Set Internal Change=Bald Eagle      ,Loc Hav         ,107333.6, 7 , 3 ,620.7958
Set Internal Change=Bald Eagle      ,Loc Hav         ,106466.0, 7 , 3 ,619.9756
Set Internal Change=Bald Eagle      ,Loc Hav         ,105178.6, 7 , 3 ,619.3922
Set Internal Change=Bald Eagle      ,Loc Hav         ,104647.2, 7 , 3 ,618.8516
Set Internal Change=Bald Eagle      ,Loc Hav         ,104195.0, 7 , 3 ,618.5269
Set Internal Change=Bald Eagle      ,Loc Hav         ,103854.0, 7 , 3 ,618.4033
Set Internal Change=Bald Eagle      ,Loc Hav         ,103369.7, 7 , 3 ,618.1957
Set Internal Change=Bald Eagle      ,Loc Hav         ,103122.3, 7 , 3 ,617.5002
Set Internal Change=Bald Eagle      ,Loc Hav         ,101440.3, 7 , 3 ,615.438
Set Internal Change=Bald Eagle      ,Loc Hav         ,100657.3, 7 , 3 ,614.7339
Set Internal Change=Bald Eagle      ,Loc Hav         ,99452.75, 7 , 3 ,614.1096
Set Internal Change=Bald Eagle      ,Loc Hav         ,98206.87, 7 , 3 ,613.5639
Set Internal Change=Bald Eagle      ,Loc Hav         ,97607.35, 7 , 3 ,612.4305
Set Internal Change=Bald Eagle      ,Loc Hav         ,96370.43, 7 , 3 ,609.6848
Set Internal Change=Bald Eagle      ,Loc Hav         ,94560.01, 7 , 3 ,606.6964
Set Internal Change=Bald Eagle      ,Loc Hav         ,93391.71, 7 , 3 ,605.2018
Set Internal Change=Bald Eagle      ,Loc Hav         ,92011.85, 7 , 3 ,603.972
Set Internal Change=Bald Eagle      ,Loc Hav         ,91030.01, 7 , 3 ,603.0748
Set Internal Change=Bald Eagle      ,Loc Hav         ,90096.99, 7 , 3 ,602.4637
Set Internal Change=Bald Eagle      ,Loc Hav         ,89060.69, 7 , 3 ,602.1946
Set Internal Change=Bald Eagle      ,Loc Hav         ,87861.14, 7 , 3 ,602.0811
Set Internal Change=Bald Eagle      ,Loc Hav         ,86942.04, 7 , 3 ,602.0553
Set Internal Change=Bald Eagle      ,Loc Hav         ,85569.53, 7 , 3 ,602.0399
Set Internal Change=Bald Eagle      ,Loc Hav         ,84724.08, 7 , 3 ,602.0359
Set Internal Change=Bald Eagle      ,Loc Hav         ,83563.41, 7 , 3 ,602.0343
Set Internal Change=Bald Eagle      ,Loc Hav         ,82607.89, 7 , 3 ,602.0339
Set Internal Change=Bald Eagle      ,Loc Hav         ,81849.41, 7 , 3 ,601.6992
Set Internal Change=Bald Eagle      ,Loc Hav         ,81084.18, 7 , 3 ,589.2798
Set Internal Change=Bald Eagle      ,Loc Hav         ,80500.50, 7 , 3 ,587.7585
Set Internal Change=Bald Eagle      ,Loc Hav         ,79684.28, 7 , 3 ,587.1365
Set Internal Change=Bald Eagle      ,Loc Hav         ,78627.87, 7 , 3 ,586.8135
Set Internal Change=Bald Eagle      ,Loc Hav         ,76643.40, 7 , 3 ,585.0086
Set Internal Change=Bald Eagle      ,Loc Hav         ,76002.96, 7 , 3 ,584.2377
Set Internal Change=Bald Eagle      ,Loc Hav         ,75917.82, 7 , 3 ,584.1003
Set Internal Change=Bald Eagle      ,Loc Hav         ,75616.14, 7 , 3 ,583.662
Set Internal Change=Bald Eagle      ,Loc Hav         ,74650.60, 7 , 3 ,582.8613
Set Internal Change=Bald Eagle      ,Loc Hav         ,74207.96, 7 , 3 ,582.5439
Set Internal Change=Bald Eagle      ,Loc Hav         ,73504.24, 7 , 3 ,581.8551
Set Internal Change=Bald Eagle      ,Loc Hav         ,72303.68, 7 , 3 ,580.7312
Set Internal Change=Bald Eagle      ,Loc Hav         ,71400.81, 7 , 3 ,579.7382
Set Internal Change=Bald Eagle      ,Loc Hav         ,70651.52, 7 , 3 ,579.0096
Set Internal Change=Bald Eagle      ,Loc Hav         ,69567.33, 7 , 3 ,578.1696
Set Internal Change=Bald Eagle      ,Loc Hav         ,68604.09, 7 , 3 ,577.5957
Set Internal Change=Bald Eagle      ,Loc Hav         ,67326.78, 7 , 3 ,576.9186
Set Internal Change=Bald Eagle      ,Loc Hav         ,66070.17, 7 , 3 ,575.9827
Set Internal Change=Bald Eagle      ,Loc Hav         ,64908.02, 7 , 3 ,574.7183
Set Internal Change=Bald Eagle      ,Loc Hav         ,63812.99, 7 , 3 ,573.4046
Set Internal Change=Bald Eagle      ,Loc Hav         ,62746.41, 7 , 3 ,572.2603
Set Internal Change=Bald Eagle      ,Loc Hav         ,61896.89, 7 , 3 ,571.3497
Set Internal Change=Bald Eagle      ,Loc Hav         ,60901.09, 7 , 3 ,570.2592
Set Internal Change=Bald Eagle      ,Loc Hav         ,59795.28, 7 , 3 ,569.0324
Set Internal Change=Bald Eagle      ,Loc Hav         ,58836.23, 7 , 3 ,568.309
Set Internal Change=Bald Eagle      ,Loc Hav         ,58708.54, 7 , 3 ,568.2343
Set Internal Change=Bald Eagle      ,Loc Hav         ,58091.91, 7 , 3 ,567.7802
Set Internal Change=Bald Eagle      ,Loc Hav         ,57700.27, 7 , 3 ,567.4079
Set Internal Change=Bald Eagle      ,Loc Hav         ,57250.60, 7 , 3 ,567.1323
Set Internal Change=Bald Eagle      ,Loc Hav         ,56775.92, 7 , 3 ,566.7408
Set Internal Change=Bald Eagle      ,Loc Hav         ,56243.79, 7 , 3 ,566.2703
Set Internal Change=Bald Eagle      ,Loc Hav         ,55700.55, 7 , 3 ,565.8155
Set Internal Change=Bald Eagle      ,Loc Hav         ,54696.51, 7 , 3 ,565.0797
Set Internal Change=Bald Eagle      ,Loc Hav         ,53922.53, 7 , 3 ,564.56
Set Internal Change=Bald Eagle      ,Loc Hav         ,52879.19, 7 , 3 ,564.0378
Set Internal Change=Bald Eagle      ,Loc Hav         ,51784.74, 7 , 3 ,563.6132
Set Internal Change=Bald Eagle      ,Loc Hav         ,50720.68, 7 , 3 ,563.3371
Set Internal Change=Bald Eagle      ,Loc Hav         ,49715.77, 7 , 3 ,562.9927
Set Internal Change=Bald Eagle      ,Loc Hav         ,48965.94, 7 , 3 ,562.6715
Set Internal Change=Bald Eagle      ,Loc Hav         ,48110.09, 7 , 3 ,561.8245
Set Internal Change=Bald Eagle      ,Loc Hav         ,47453.14, 7 , 3 ,561.1531
Set Internal Change=Bald Eagle      ,Loc Hav         ,46722.59, 7 , 3 ,560.5298
Set Internal Change=Bald Eagle      ,Loc Hav         ,46310.48, 7 , 3 ,560.2607
Set Internal Change=Bald Eagle      ,Loc Hav         ,45805.37, 7 , 3 ,560.054
Set Internal Change=Bald Eagle      ,Loc Hav         ,45233.89, 7 , 3 ,559.8801
Set Internal Change=Bald Eagle      ,Loc Hav         ,44529.29, 7 , 3 ,559.6061
Set Internal Change=Bald Eagle      ,Loc Hav         ,43919.30, 7 , 3 ,559.3687
Set Internal Change=Bald Eagle      ,Loc Hav         ,42895.87, 7 , 3 ,558.7084
Set Internal Change=Bald Eagle      ,Loc Hav         ,41806.43, 7 , 3 ,557.8964
Set Internal Change=Bald Eagle      ,Loc Hav         ,40526.85, 7 , 3 ,557.1392
Set Internal Change=Bald Eagle      ,Loc Hav         ,39499.37, 7 , 3 ,556.7703
Set Internal Change=Bald Eagle      ,Loc Hav         ,38446.87, 7 , 3 ,556.2866
Set Internal Change=Bald Eagle      ,Loc Hav         ,37962.54, 7 , 3 ,555.9526
Set Internal Change=Bald Eagle      ,Loc Hav         ,37385.23, 7 , 3 ,555.729
Set Internal Change=Bald Eagle      ,Loc Hav         ,36769.88, 7 , 3 ,555.6369
Set Internal Change=Bald Eagle      ,Loc Hav         ,36663.76, 7 , 3 ,555.5922
Set Internal Change=Bald Eagle      ,Loc Hav         ,36339.56, 7 , 3 ,555.4222
Set Internal Change=Bald Eagle      ,Loc Hav         ,35648.50, 7 , 3 ,555.1895
Set Internal Change=Bald Eagle      ,Loc Hav         ,35072.37, 7 , 3 ,555.0789
Set Internal Change=Bald Eagle      ,Loc Hav         ,34098.93, 7 , 3 ,554.8278
Set Internal Change=Bald Eagle      ,Loc Hav         ,33498.68, 7 , 3 ,554.6928
Set Internal Change=Bald Eagle      ,Loc Hav         ,32195.47, 7 , 3 ,553.8997
Set Internal Change=Bald Eagle      ,Loc Hav         ,30878.12, 7 , 3 ,553.0305
Set Internal Change=Bald Eagle      ,Loc Hav         ,29563.77, 7 , 3 ,552.4784
Set Internal Change=Bald Eagle      ,Loc Hav         ,27226.40, 7 , 3 ,550.7739
Set Internal Change=Bald Eagle      ,Loc Hav         ,25960.70, 7 , 3 ,548.8986
Set Internal Change=Bald Eagle      ,Loc Hav         ,24843.25, 7 , 3 ,547.7488
Set Internal Change=Bald Eagle      ,Loc Hav         ,24417.73, 7 , 3 ,547.5668
Set Internal Change=Bald Eagle      ,Loc Hav         ,23872.06, 7 , 3 ,546.7662
Set Internal Change=Bald Eagle      ,Loc Hav         ,23783.65, 7 , 3 ,546.7382
Set Internal Change=Bald Eagle      ,Loc Hav         ,23384.79, 7 , 3 ,546.5565
Set Internal Change=Bald Eagle      ,Loc Hav         ,22982.97, 7 , 3 ,546.1524
Set Internal Change=Bald Eagle      ,Loc Hav         ,22386.15, 7 , 3 ,545.517
Set Internal Change=Bald Eagle      ,Loc Hav         ,21283.34, 7 , 3 ,545.0597
Set Internal Change=Bald Eagle      ,Loc Hav         ,21199.93, 7 , 3 ,545.0536
Set Internal Change=Bald Eagle      ,Loc Hav         ,20127.30, 7 , 3 ,544.876
Set Internal Change=Bald Eagle      ,Loc Hav         ,19036.24, 7 , 3 ,543.18
Set Internal Change=Bald Eagle      ,Loc Hav         ,18200.10, 7 , 3 ,541.9213
Set Internal Change=Bald Eagle      ,Loc Hav         ,17549.23, 7 , 3 ,541.7288
Set Internal Change=Bald Eagle      ,Loc Hav         ,16787.45, 7 , 3 ,541.5739
Set Internal Change=Bald Eagle      ,Loc Hav         ,15407.88, 7 , 3 ,541.1331
Set Internal Change=Bald Eagle      ,Loc Hav         ,14814.34, 7 , 3 ,540.7659
Set Internal Change=Bald Eagle      ,Loc Hav         ,13326.74, 7 , 3 ,540.2061
Set Internal Change=Bald Eagle      ,Loc Hav         ,12035.22, 7 , 3 ,539.9366
Set Internal Change=Bald Eagle      ,Loc Hav         ,11865.80, 7 , 3 ,539.9095
Set Internal Change=Bald Eagle      ,Loc Hav         ,11116.44, 7 , 3 ,539.4785
Set Internal Change=Bald Eagle      ,Loc Hav         ,10995.73, 7 , 3 ,539.3681
Set Internal Change=Bald Eagle      ,Loc Hav         ,10221.14, 7 , 3 ,538.4836
Set Internal Change=Bald Eagle      ,Loc Hav         ,9258.941, 7 , 3 ,537.7561
Set Internal Change=Bald Eagle      ,Loc Hav         ,8541.462, 7 , 3 ,537.5622
Set Internal Change=Bald Eagle      ,Loc Hav         ,7936.130, 7 , 3 ,537.3939
Set Internal Change=Bald Eagle      ,Loc Hav         ,6940.066, 7 , 3 ,536.9075
Set Internal Change=Bald Eagle      ,Loc Hav         ,6267.489, 7 , 3 ,536.5667
Set Internal Change=Bald Eagle      ,Loc Hav         ,5523.234, 7 , 3 ,536.3096
Set Internal Change=Bald Eagle      ,Loc Hav         ,4293.710, 7 , 3 ,535.8135
Set Internal Change=Bald Eagle      ,Loc Hav         ,3047.378, 7 , 3 ,535.0403
Set Internal Change=Bald Eagle      ,Loc Hav         ,2731.142, 7 , 3 ,534.4341
Set Internal Change=Bald Eagle      ,Loc Hav         ,2501.017, 7 , 3 ,534.2289
Set Internal Change=Bald Eagle      ,Loc Hav         ,2371.827, 7 , 3 ,534.0695
Set Internal Change=Bald Eagle      ,Loc Hav         ,1692.633, 7 , 3 ,533.8013
Set Internal Change=Bald Eagle      ,Loc Hav         ,1212.855, 7 , 3 ,533.6951
Set Internal Change=Bald Eagle      ,Loc Hav         ,659.942 , 7 , 3 ,532.9138
Set Internal Change=Bald Eagle      ,Loc Hav         ,138154.4, 8 , 3 ,666.5416
Set Internal Change=Bald Eagle      ,Loc Hav         ,137690.8, 8 , 3 ,666.1302
Set Internal Change=Bald Eagle      ,Loc Hav         ,137327.0, 8 , 3 ,665.7102
Set Internal Change=Bald Eagle      ,Loc Hav         ,136564.9, 8 , 3 ,663.1218
Set Internal Change=Bald Eagle      ,Loc Hav         ,136202.3, 8 , 3 ,662.4777
Set Internal Change=Bald Eagle      ,Loc Hav         ,135591.4, 8 , 3 ,661.2397
Set Internal Change=Bald Eagle      ,Loc Hav         ,135068.7, 8 , 3 ,660.5219
Set Internal Change=Bald Eagle      ,Loc Hav         ,134487.2, 8 , 3 ,659.4244
Set Internal Change=Bald Eagle      ,Loc Hav         ,133881.0, 8 , 3 ,658.6542
Set Internal Change=Bald Eagle      ,Loc Hav         ,133446.1, 8 , 3 ,658.1563
Set Internal Change=Bald Eagle      ,Loc Hav         ,132973.6, 8 , 3 ,657.5983
Set Internal Change=Bald Eagle      ,Loc Hav         ,132363.8, 8 , 3 ,656.486
Set Internal Change=Bald Eagle      ,Loc Hav         ,131699.7, 8 , 3 ,654.6781
Set Internal Change=Bald Eagle      ,Loc Hav         ,130997.6, 8 , 3 ,652.7528
Set Internal Change=Bald Eagle      ,Loc Hav         ,130339.2, 8 , 3 ,651.3515
Set Internal Change=Bald Eagle      ,Loc Hav         ,129627.5, 8 , 3 ,649.9632
Set Internal Change=Bald Eagle      ,Loc Hav         ,128760.7, 8 , 3 ,648.049
Set Internal Change=Bald Eagle      ,Loc Hav         ,128280.7, 8 , 3 ,647.1489
Set Internal Change=Bald Eagle      ,Loc Hav         ,127410.9, 8 , 3 ,646.1641
Set Internal Change=Bald Eagle      ,Loc Hav         ,126741.0, 8 , 3 ,645.395
Set Internal Change=Bald Eagle      ,Loc Hav         ,126454.1, 8 , 3 ,644.8414
Set Internal Change=Bald Eagle      ,Loc Hav         ,126062.6, 8 , 3 ,644.1631
Set Internal Change=Bald Eagle      ,Loc Hav         ,125704.7, 8 , 3 ,643.5967
Set Internal Change=Bald Eagle      ,Loc Hav         ,125091.9, 8 , 3 ,642.7098
Set Internal Change=Bald Eagle      ,Loc Hav         ,124615.5, 8 , 3 ,642.2669
Set Internal Change=Bald Eagle      ,Loc Hav         ,124025.0, 8 , 3 ,640.9113
Set Internal Change=Bald Eagle      ,Loc Hav         ,123503.5, 8 , 3 ,639.7667
Set Internal Change=Bald Eagle      ,Loc Hav         ,123123.6, 8 , 3 ,639.1177
Set Internal Change=Bald Eagle      ,Loc Hav         ,122703.3, 8 , 3 ,638.5634
Set Internal Change=Bald Eagle      ,Loc Hav         ,122190.8, 8 , 3 ,637.8339
Set Internal Change=Bald Eagle      ,Loc Hav         ,121754.0, 8 , 3 ,637.3149
Set Internal Change=Bald Eagle      ,Loc Hav         ,121394.1, 8 , 3 ,637.0081
Set Internal Change=Bald Eagle      ,Loc Hav         ,120862.6, 8 , 3 ,636.4645
Set Internal Change=Bald Eagle      ,Loc Hav         ,120421.4, 8 , 3 ,635.7104
Set Internal Change=Bald Eagle      ,Loc Hav         ,119954.9, 8 , 3 ,635.0569
Set Internal Change=Bald Eagle      ,Loc Hav         ,119473.8, 8 , 3 ,634.1836
Set Internal Change=Bald Eagle      ,Loc Hav         ,118901.0, 8 , 3 ,632.8372
Set Internal Change=Bald Eagle      ,Loc Hav         ,118300.5, 8 , 3 ,631.9423
Set Internal Change=Bald Eagle      ,Loc Hav         ,117753.9, 8 , 3 ,631.4166
Set Internal Change=Bald Eagle      ,Loc Hav         ,117180.8, 8 , 3 ,630.6619
Set Internal Change=Bald Eagle      ,Loc Hav         ,116401.3, 8 , 3 ,629.8442
Set Internal Change=Bald Eagle      ,Loc Hav         ,115584.2, 8 , 3 ,629.1237
Set Internal Change=Bald Eagle      ,Loc Hav         ,114899.8, 8 , 3 ,628.2551
Set Internal Change=Bald Eagle      ,Loc Hav         ,113985.6, 8 , 3 ,627.1633
Set Internal Change=Bald Eagle      ,Loc Hav         ,112856.9, 8 , 3 ,626.199
Set Internal Change=Bald Eagle      ,Loc Hav         ,111971.0, 8 , 3 ,625.3006
Set Internal Change=Bald Eagle      ,Loc Hav         ,110657.4, 8 , 3 ,624.1948
Set Internal Change=Bald Eagle      ,Loc Hav         ,109659.9, 8 , 3 ,623.4368
Set Internal Change=Bald Eagle      ,Loc Hav         ,108600.1, 8 , 3 ,622.7261
Set Internal Change=Bald Eagle      ,Loc Hav         ,107333.6, 8 , 3 ,621.4766
Set Internal Change=Bald Eagle      ,Loc Hav         ,106466.0, 8 , 3 ,620.7007
Set Internal Change=Bald Eagle      ,Loc Hav         ,105178.6, 8 , 3 ,620.1226
Set Internal Change=Bald Eagle      ,Loc Hav         ,104647.2, 8 , 3 ,619.6551
Set Internal Change=Bald Eagle      ,Loc Hav         ,104195.0, 8 , 3 ,619.3572
Set Internal Change=Bald Eagle      ,Loc Hav         ,103854.0, 8 , 3 ,619.2273
Set Internal Change=Bald Eagle      ,Loc Hav         ,103369.7, 8 , 3 ,618.9971
Set Internal Change=Bald Eagle      ,Loc Hav         ,103122.3, 8 , 3 ,618.1543
Set Internal Change=Bald Eagle      ,Loc Hav         ,101440.3, 8 , 3 ,616.1637
Set Internal Change=Bald Eagle      ,Loc Hav         ,100657.3, 8 , 3 ,615.4977
Set Internal Change=Bald Eagle      ,Loc Hav         ,99452.75, 8 , 3 ,614.8958
Set Internal Change=Bald Eagle      ,Loc Hav         ,98206.87, 8 , 3 ,614.3576
Set Internal Change=Bald Eagle      ,Loc Hav         ,97607.35, 8 , 3 ,613.1478
Set Internal Change=Bald Eagle      ,Loc Hav         ,96370.43, 8 , 3 ,610.3108
Set Internal Change=Bald Eagle      ,Loc Hav         ,94560.01, 8 , 3 ,607.6224
Set Internal Change=Bald Eagle      ,Loc Hav         ,93391.71, 8 , 3 ,606.7668
Set Internal Change=Bald Eagle      ,Loc Hav         ,92011.85, 8 , 3 ,606.2604
Set Internal Change=Bald Eagle      ,Loc Hav         ,91030.01, 8 , 3 ,606.0341
Set Internal Change=Bald Eagle      ,Loc Hav         ,90096.99, 8 , 3 ,605.9167
Set Internal Change=Bald Eagle      ,Loc Hav         ,89060.69, 8 , 3 ,605.8658
Set Internal Change=Bald Eagle      ,Loc Hav         ,87861.14, 8 , 3 ,605.8424
Set Internal Change=Bald Eagle      ,Loc Hav         ,86942.04, 8 , 3 ,605.8367
Set Internal Change=Bald Eagle      ,Loc Hav         ,85569.53, 8 , 3 ,605.8326
Set Internal Change=Bald Eagle      ,Loc Hav         ,84724.08, 8 , 3 ,605.8314
Set Internal Change=Bald Eagle      ,Loc Hav         ,83563.41, 8 , 3 ,605.8309
Set Internal Change=Bald Eagle      ,Loc Hav         ,82607.89, 8 , 3 ,605.8308
Set Internal Change=Bald Eagle      ,Loc Hav         ,81849.41, 8 , 3 ,605.621
Set Internal Change=Bald Eagle      ,Loc Hav         ,81084.18, 8 , 3 ,589.8715
Set Internal Change=Bald Eagle      ,Loc Hav         ,80500.50, 8 , 3 ,588.3657
Set Internal Change=Bald Eagle      ,Loc Hav         ,79684.28, 8 , 3 ,587.7006
Set Internal Change=Bald Eagle      ,Loc Hav         ,78627.87, 8 , 3 ,587.3596
Set Internal Change=Bald Eagle      ,Loc Hav         ,76643.40, 8 , 3 ,585.5048
Set Internal Change=Bald Eagle      ,Loc Hav         ,76002.96, 8 , 3 ,584.7842
Set Internal Change=Bald Eagle      ,Loc Hav         ,75917.82, 8 , 3 ,584.6601
Set Internal Change=Bald Eagle      ,Loc Hav         ,75616.14, 8 , 3 ,584.1978
Set Internal Change=Bald Eagle      ,Loc Hav         ,74650.60, 8 , 3 ,583.3323
Set Internal Change=Bald Eagle      ,Loc Hav         ,74207.96, 8 , 3 ,583.0045
Set Internal Change=Bald Eagle      ,Loc Hav         ,73504.24, 8 , 3 ,582.3608
Set Internal Change=Bald Eagle      ,Loc Hav         ,72303.68, 8 , 3 ,581.3575
Set Internal Change=Bald Eagle      ,Loc Hav         ,71400.81, 8 , 3 ,580.3481
Set Internal Change=Bald Eagle      ,Loc Hav         ,70651.52, 8 , 3 ,579.6023
Set Internal Change=Bald Eagle      ,Loc Hav         ,69567.33, 8 , 3 ,578.7651
Set Internal Change=Bald Eagle      ,Loc Hav         ,68604.09, 8 , 3 ,578.2263
Set Internal Change=Bald Eagle      ,Loc Hav         ,67326.78, 8 , 3 ,577.5381
Set Internal Change=Bald Eagle      ,Loc Hav         ,66070.17, 8 , 3 ,576.5751
Set Internal Change=Bald Eagle      ,Loc Hav         ,64908.02, 8 , 3 ,575.2706
Set Internal Change=Bald Eagle      ,Loc Hav         ,63812.99, 8 , 3 ,573.9512
Set Internal Change=Bald Eagle      ,Loc Hav         ,62746.41, 8 , 3 ,572.8541
Set Internal Change=Bald Eagle      ,Loc Hav         ,61896.89, 8 , 3 ,571.9585
Set Internal Change=Bald Eagle      ,Loc Hav         ,60901.09, 8 , 3 ,570.8625
Set Internal Change=Bald Eagle      ,Loc Hav         ,59795.28, 8 , 3 ,569.7
Set Internal Change=Bald Eagle      ,Loc Hav         ,58836.23, 8 , 3 ,569.0311
Set Internal Change=Bald Eagle      ,Loc Hav         ,58708.54, 8 , 3 ,568.96
Set Internal Change=Bald Eagle      ,Loc Hav         ,58091.91, 8 , 3 ,568.5229
Set Internal Change=Bald Eagle      ,Loc Hav         ,57700.27, 8 , 3 ,568.1494
Set Internal Change=Bald Eagle      ,Loc Hav         ,57250.60, 8 , 3 ,567.9036
Set Internal Change=Bald Eagle      ,Loc Hav         ,56775.92, 8 , 3 ,567.5317
Set Internal Change=Bald Eagle      ,Loc Hav         ,56243.79, 8 , 3 ,567.1359
Set Internal Change=Bald Eagle      ,Loc Hav         ,55700.55, 8 , 3 ,566.7594
Set Internal Change=Bald Eagle      ,Loc Hav         ,54696.51, 8 , 3 ,566.1401
Set Internal Change=Bald Eagle      ,Loc Hav         ,53922.53, 8 , 3 ,565.5955
Set Internal Change=Bald Eagle      ,Loc Hav         ,52879.19, 8 , 3 ,565.0099
Set Internal Change=Bald Eagle      ,Loc Hav         ,51784.74, 8 , 3 ,564.4851
Set Internal Change=Bald Eagle      ,Loc Hav         ,50720.68, 8 , 3 ,564.1458
Set Internal Change=Bald Eagle      ,Loc Hav         ,49715.77, 8 , 3 ,563.8739
Set Internal Change=Bald Eagle      ,Loc Hav         ,48965.94, 8 , 3 ,563.5847
Set Internal Change=Bald Eagle      ,Loc Hav         ,48110.09, 8 , 3 ,562.6714
Set Internal Change=Bald Eagle      ,Loc Hav         ,47453.14, 8 , 3 ,562.0016
Set Internal Change=Bald Eagle      ,Loc Hav         ,46722.59, 8 , 3 ,561.3961
Set Internal Change=Bald Eagle      ,Loc Hav         ,46310.48, 8 , 3 ,561.1311
Set Internal Change=Bald Eagle      ,Loc Hav         ,45805.37, 8 , 3 ,560.9044
Set Internal Change=Bald Eagle      ,Loc Hav         ,45233.89, 8 , 3 ,560.6936
Set Internal Change=Bald Eagle      ,Loc Hav         ,44529.29, 8 , 3 ,560.3625
Set Internal Change=Bald Eagle      ,Loc Hav         ,43919.30, 8 , 3 ,560.1293
Set Internal Change=Bald Eagle      ,Loc Hav         ,42895.87, 8 , 3 ,559.4484
Set Internal Change=Bald Eagle      ,Loc Hav         ,41806.43, 8 , 3 ,558.6041
Set Internal Change=Bald Eagle      ,Loc Hav         ,40526.85, 8 , 3 ,557.8654
Set Internal Change=Bald Eagle      ,Loc Hav         ,39499.37, 8 , 3 ,557.5069
Set Internal Change=Bald Eagle      ,Loc Hav         ,38446.87, 8 , 3 ,557.0249
Set Internal Change=Bald Eagle      ,Loc Hav         ,37962.54, 8 , 3 ,556.6879
Set Internal Change=Bald Eagle      ,Loc Hav         ,37385.23, 8 , 3 ,556.4586
Set Internal Change=Bald Eagle      ,Loc Hav         ,36769.88, 8 , 3 ,556.3541
Set Internal Change=Bald Eagle      ,Loc Hav         ,36663.76, 8 , 3 ,556.307
Set Internal Change=Bald Eagle      ,Loc Hav         ,36339.56, 8 , 3 ,556.1044
Set Internal Change=Bald Eagle      ,Loc Hav         ,35648.50, 8 , 3 ,555.8408
Set Internal Change=Bald Eagle      ,Loc Hav         ,35072.37, 8 , 3 ,555.7122
Set Internal Change=Bald Eagle      ,Loc Hav         ,34098.93, 8 , 3 ,555.4509
Set Internal Change=Bald Eagle      ,Loc Hav         ,33498.68, 8 , 3 ,555.3047
Set Internal Change=Bald Eagle      ,Loc Hav         ,32195.47, 8 , 3 ,554.4592
Set Internal Change=Bald Eagle      ,Loc Hav         ,30878.12, 8 , 3 ,553.5487
Set Internal Change=Bald Eagle      ,Loc Hav         ,29563.77, 8 , 3 ,552.9368
Set Internal Change=Bald Eagle      ,Loc Hav         ,27226.40, 8 , 3 ,551.1277
Set Internal Change=Bald Eagle      ,Loc Hav         ,25960.70, 8 , 3 ,549.1501
Set Internal Change=Bald Eagle      ,Loc Hav         ,24843.25, 8 , 3 ,547.9358
Set Internal Change=Bald Eagle      ,Loc Hav         ,24417.73, 8 , 3 ,547.7549
Set Internal Change=Bald Eagle      ,Loc Hav         ,23872.06, 8 , 3 ,546.9045
Set Internal Change=Bald Eagle      ,Loc Hav         ,23783.65, 8 , 3 ,546.873
Set Internal Change=Bald Eagle      ,Loc Hav         ,23384.79, 8 , 3 ,546.6728
Set Internal Change=Bald Eagle      ,Loc Hav         ,22982.97, 8 , 3 ,546.2913
Set Internal Change=Bald Eagle      ,Loc Hav         ,22386.15, 8 , 3 ,545.6865
Set Internal Change=Bald Eagle      ,Loc Hav         ,21283.34, 8 , 3 ,545.2228
Set Internal Change=Bald Eagle      ,Loc Hav         ,21199.93, 8 , 3 ,545.2161
Set Internal Change=Bald Eagle      ,Loc Hav         ,20127.30, 8 , 3 ,545.0257
Set Internal Change=Bald Eagle      ,Loc Hav         ,19036.24, 8 , 3 ,543.2991
Set Internal Change=Bald Eagle      ,Loc Hav         ,18200.10, 8 , 3 ,542.0222
Set Internal Change=Bald Eagle      ,Loc Hav         ,17549.23, 8 , 3 ,541.8243
Set Internal Change=Bald Eagle      ,Loc Hav         ,16787.45, 8 , 3 ,541.6638
Set Internal Change=Bald Eagle      ,Loc Hav         ,15407.88, 8 , 3 ,541.2099
Set Internal Change=Bald Eagle      ,Loc Hav         ,14814.34, 8 , 3 ,540.8331
Set Internal Change=Bald Eagle      ,Loc Hav         ,13326.74, 8 , 3 ,540.2579
Set Internal Change=Bald Eagle      ,Loc Hav         ,12035.22, 8 , 3 ,539.9789
Set Internal Change=Bald Eagle      ,Loc Hav         ,11865.80, 8 , 3 ,539.9508
Set Internal Change=Bald Eagle      ,Loc Hav         ,11116.44, 8 , 3 ,539.5156
Set Internal Change=Bald Eagle      ,Loc Hav         ,10995.73, 8 , 3 ,539.4055
Set Internal Change=Bald Eagle      ,Loc Hav         ,10221.14, 8 , 3 ,538.5213
Set Internal Change=Bald Eagle      ,Loc Hav         ,9258.941, 8 , 3 ,537.7916
Set Internal Change=Bald Eagle      ,Loc Hav         ,8541.462, 8 , 3 ,537.5951
Set Internal Change=Bald Eagle      ,Loc Hav         ,7936.130, 8 , 3 ,537.424
Set Internal Change=Bald Eagle      ,Loc Hav         ,6940.066, 8 , 3 ,536.935
Set Internal Change=Bald Eagle      ,Loc Hav         ,6267.489, 8 , 3 ,536.5929
Set Internal Change=Bald Eagle      ,Loc Hav         ,5523.234, 8 , 3 ,536.3337
Set Internal Change=Bald Eagle      ,Loc Hav         ,4293.710, 8 , 3 ,535.8344
Set Internal Change=Bald Eagle      ,Loc Hav         ,3047.378, 8 , 3 ,535.0579
Set Internal Change=Bald Eagle      ,Loc Hav         ,2731.142, 8 , 3 ,534.4458
Set Internal Change=Bald Eagle      ,Loc Hav         ,2501.017, 8 , 3 ,534.2396
Set Internal Change=Bald Eagle      ,Loc Hav         ,2371.827, 8 , 3 ,534.08
Set Internal Change=Bald Eagle      ,Loc Hav         ,1692.633, 8 , 3 ,533.8123
Set Internal Change=Bald Eagle      ,Loc Hav         ,1212.855, 8 , 3 ,533.7054
Set Internal Change=Bald Eagle      ,Loc Hav         ,659.942 , 8 , 3 ,532.9362
Set Internal Change=Bald Eagle      ,Loc Hav         ,138154.4, 9 , 3 ,667.1921
Set Internal Change=Bald Eagle      ,Loc Hav         ,137690.8, 9 , 3 ,666.7961
Set Internal Change=Bald Eagle      ,Loc Hav         ,137327.0, 9 , 3 ,666.3657
Set Internal Change=Bald Eagle      ,Loc Hav         ,136564.9, 9 , 3 ,663.6649
Set Internal Change=Bald Eagle      ,Loc Hav         ,136202.3, 9 , 3 ,663.0466
Set Internal Change=Bald Eagle      ,Loc Hav         ,135591.4, 9 , 3 ,661.7818
Set Internal Change=Bald Eagle      ,Loc Hav         ,135068.7, 9 , 3 ,661.0731
Set Internal Change=Bald Eagle      ,Loc Hav         ,134487.2, 9 , 3 ,659.9648
Set Internal Change=Bald Eagle      ,Loc Hav         ,133881.0, 9 , 3 ,659.1932
Set Internal Change=Bald Eagle      ,Loc Hav         ,133446.1, 9 , 3 ,658.6841
Set Internal Change=Bald Eagle      ,Loc Hav         ,132973.6, 9 , 3 ,658.1198
Set Internal Change=Bald Eagle      ,Loc Hav         ,132363.8, 9 , 3 ,656.9472
Set Internal Change=Bald Eagle      ,Loc Hav         ,131699.7, 9 , 3 ,655.1039
Set Internal Change=Bald Eagle      ,Loc Hav         ,130997.6, 9 , 3 ,653.1975
Set Internal Change=Bald Eagle      ,Loc Hav         ,130339.2, 9 , 3 ,651.7412
Set Internal Change=Bald Eagle      ,Loc Hav         ,129627.5, 9 , 3 ,650.2473
Set Internal Change=Bald Eagle      ,Loc Hav         ,128760.7, 9 , 3 ,648.4218
Set Internal Change=Bald Eagle      ,Loc Hav         ,128280.7, 9 , 3 ,647.6223
Set Internal Change=Bald Eagle      ,Loc Hav         ,127410.9, 9 , 3 ,646.7151
Set Internal Change=Bald Eagle      ,Loc Hav         ,126741.0, 9 , 3 ,645.9648
Set Internal Change=Bald Eagle      ,Loc Hav         ,126454.1, 9 , 3 ,645.388
Set Internal Change=Bald Eagle      ,Loc Hav         ,126062.6, 9 , 3 ,644.6989
Set Internal Change=Bald Eagle      ,Loc Hav         ,125704.7, 9 , 3 ,644.1265
Set Internal Change=Bald Eagle      ,Loc Hav         ,125091.9, 9 , 3 ,643.206
Set Internal Change=Bald Eagle      ,Loc Hav         ,124615.5, 9 , 3 ,642.7438
Set Internal Change=Bald Eagle      ,Loc Hav         ,124025.0, 9 , 3 ,641.4309
Set Internal Change=Bald Eagle      ,Loc Hav         ,123503.5, 9 , 3 ,640.3241
Set Internal Change=Bald Eagle      ,Loc Hav         ,123123.6, 9 , 3 ,639.6923
Set Internal Change=Bald Eagle      ,Loc Hav         ,122703.3, 9 , 3 ,639.1525
Set Internal Change=Bald Eagle      ,Loc Hav         ,122190.8, 9 , 3 ,638.436
Set Internal Change=Bald Eagle      ,Loc Hav         ,121754.0, 9 , 3 ,637.923
Set Internal Change=Bald Eagle      ,Loc Hav         ,121394.1, 9 , 3 ,637.6071
Set Internal Change=Bald Eagle      ,Loc Hav         ,120862.6, 9 , 3 ,637.0667
Set Internal Change=Bald Eagle      ,Loc Hav         ,120421.4, 9 , 3 ,636.3087
Set Internal Change=Bald Eagle      ,Loc Hav         ,119954.9, 9 , 3 ,635.6384
Set Internal Change=Bald Eagle      ,Loc Hav         ,119473.8, 9 , 3 ,634.7363
Set Internal Change=Bald Eagle      ,Loc Hav         ,118901.0, 9 , 3 ,633.3867
Set Internal Change=Bald Eagle      ,Loc Hav         ,118300.5, 9 , 3 ,632.479
Set Internal Change=Bald Eagle      ,Loc Hav         ,117753.9, 9 , 3 ,631.9141
Set Internal Change=Bald Eagle      ,Loc Hav         ,117180.8, 9 , 3 ,631.1144
Set Internal Change=Bald Eagle      ,Loc Hav         ,116401.3, 9 , 3 ,630.2773
Set Internal Change=Bald Eagle      ,Loc Hav         ,115584.2, 9 , 3 ,629.5513
Set Internal Change=Bald Eagle      ,Loc Hav         ,114899.8, 9 , 3 ,628.7108
Set Internal Change=Bald Eagle      ,Loc Hav         ,113985.6, 9 , 3 ,627.6469
Set Internal Change=Bald Eagle      ,Loc Hav         ,112856.9, 9 , 3 ,626.6874
Set Internal Change=Bald Eagle      ,Loc Hav         ,111971.0, 9 , 3 ,625.8435
Set Internal Change=Bald Eagle      ,Loc Hav         ,110657.4, 9 , 3 ,624.7922
Set Internal Change=Bald Eagle      ,Loc Hav         ,109659.9, 9 , 3 ,624.0614
Set Internal Change=Bald Eagle      ,Loc Hav         ,108600.1, 9 , 3 ,623.3887
Set Internal Change=Bald Eagle      ,Loc Hav         ,107333.6, 9 , 3 ,622.188
Set Internal Change=Bald Eagle      ,Loc Hav         ,106466.0, 9 , 3 ,621.4409
Set Internal Change=Bald Eagle      ,Loc Hav         ,105178.6, 9 , 3 ,620.8657
Set Internal Change=Bald Eagle      ,Loc Hav         ,104647.2, 9 , 3 ,620.4377
Set Internal Change=Bald Eagle      ,Loc Hav         ,104195.0, 9 , 3 ,620.1439
Set Internal Change=Bald Eagle      ,Loc Hav         ,103854.0, 9 , 3 ,620.0072
Set Internal Change=Bald Eagle      ,Loc Hav         ,103369.7, 9 , 3 ,619.7556
Set Internal Change=Bald Eagle      ,Loc Hav         ,103122.3, 9 , 3 ,618.7904
Set Internal Change=Bald Eagle      ,Loc Hav         ,101440.3, 9 , 3 ,616.7997
Set Internal Change=Bald Eagle      ,Loc Hav         ,100657.3, 9 , 3 ,616.1154
Set Internal Change=Bald Eagle      ,Loc Hav         ,99452.75, 9 , 3 ,615.4949
Set Internal Change=Bald Eagle      ,Loc Hav         ,98206.87, 9 , 3 ,614.9609
Set Internal Change=Bald Eagle      ,Loc Hav         ,97607.35, 9 , 3 ,613.5977
Set Internal Change=Bald Eagle      ,Loc Hav         ,96370.43, 9 , 3 ,611.3103
Set Internal Change=Bald Eagle      ,Loc Hav         ,94560.01, 9 , 3 ,610.2094
Set Internal Change=Bald Eagle      ,Loc Hav         ,93391.71, 9 , 3 ,610.0334
Set Internal Change=Bald Eagle      ,Loc Hav         ,92011.85, 9 , 3 ,609.9268
Set Internal Change=Bald Eagle      ,Loc Hav         ,91030.01, 9 , 3 ,609.8679
Set Internal Change=Bald Eagle      ,Loc Hav         ,90096.99, 9 , 3 ,609.8417
Set Internal Change=Bald Eagle      ,Loc Hav         ,89060.69, 9 , 3 ,609.8278
Set Internal Change=Bald Eagle      ,Loc Hav         ,87861.14, 9 , 3 ,609.8211
Set Internal Change=Bald Eagle      ,Loc Hav         ,86942.04, 9 , 3 ,609.8193
Set Internal Change=Bald Eagle      ,Loc Hav         ,85569.53, 9 , 3 ,609.8179
Set Internal Change=Bald Eagle      ,Loc Hav         ,84724.08, 9 , 3 ,609.8174
Set Internal Change=Bald Eagle      ,Loc Hav         ,83563.41, 9 , 3 ,609.8173
Set Internal Change=Bald Eagle      ,Loc Hav         ,82607.89, 9 , 3 ,609.8171
Set Internal Change=Bald Eagle      ,Loc Hav         ,81849.41, 9 , 3 ,609.7243
Set Internal Change=Bald Eagle      ,Loc Hav         ,81084.18, 9 , 3 ,590.4491
Set Internal Change=Bald Eagle      ,Loc Hav         ,80500.50, 9 , 3 ,588.9534
Set Internal Change=Bald Eagle      ,Loc Hav         ,79684.28, 9 , 3 ,588.2588
Set Internal Change=Bald Eagle      ,Loc Hav         ,78627.87, 9 , 3 ,587.9025
Set Internal Change=Bald Eagle      ,Loc Hav         ,76643.40, 9 , 3 ,585.968
Set Internal Change=Bald Eagle      ,Loc Hav         ,76002.96, 9 , 3 ,585.2437
Set Internal Change=Bald Eagle      ,Loc Hav         ,75917.82, 9 , 3 ,585.1179
Set Internal Change=Bald Eagle      ,Loc Hav         ,75616.14, 9 , 3 ,584.6459
Set Internal Change=Bald Eagle      ,Loc Hav         ,74650.60, 9 , 3 ,583.7678
Set Internal Change=Bald Eagle      ,Loc Hav         ,74207.96, 9 , 3 ,583.4311
Set Internal Change=Bald Eagle      ,Loc Hav         ,73504.24, 9 , 3 ,582.8174
Set Internal Change=Bald Eagle      ,Loc Hav         ,72303.68, 9 , 3 ,581.9008
Set Internal Change=Bald Eagle      ,Loc Hav         ,71400.81, 9 , 3 ,580.9496
Set Internal Change=Bald Eagle      ,Loc Hav         ,70651.52, 9 , 3 ,580.2474
Set Internal Change=Bald Eagle      ,Loc Hav         ,69567.33, 9 , 3 ,579.3972
Set Internal Change=Bald Eagle      ,Loc Hav         ,68604.09, 9 , 3 ,578.8536
Set Internal Change=Bald Eagle      ,Loc Hav         ,67326.78, 9 , 3 ,578.1346
Set Internal Change=Bald Eagle      ,Loc Hav         ,66070.17, 9 , 3 ,577.1579
Set Internal Change=Bald Eagle      ,Loc Hav         ,64908.02, 9 , 3 ,575.7917
Set Internal Change=Bald Eagle      ,Loc Hav         ,63812.99, 9 , 3 ,574.3961
Set Internal Change=Bald Eagle      ,Loc Hav         ,62746.41, 9 , 3 ,573.3187
Set Internal Change=Bald Eagle      ,Loc Hav         ,61896.89, 9 , 3 ,572.4326
Set Internal Change=Bald Eagle      ,Loc Hav         ,60901.09, 9 , 3 ,571.3542
Set Internal Change=Bald Eagle      ,Loc Hav         ,59795.28, 9 , 3 ,570.2753
Set Internal Change=Bald Eagle      ,Loc Hav         ,58836.23, 9 , 3 ,569.6307
Set Internal Change=Bald Eagle      ,Loc Hav         ,58708.54, 9 , 3 ,569.5605
Set Internal Change=Bald Eagle      ,Loc Hav         ,58091.91, 9 , 3 ,569.1229
Set Internal Change=Bald Eagle      ,Loc Hav         ,57700.27, 9 , 3 ,568.7394
Set Internal Change=Bald Eagle      ,Loc Hav         ,57250.60, 9 , 3 ,568.5033
Set Internal Change=Bald Eagle      ,Loc Hav         ,56775.92, 9 , 3 ,568.1283
Set Internal Change=Bald Eagle      ,Loc Hav         ,56243.79, 9 , 3 ,567.7555
Set Internal Change=Bald Eagle      ,Loc Hav         ,55700.55, 9 , 3 ,567.3976
Set Internal Change=Bald Eagle      ,Loc Hav         ,54696.51, 9 , 3 ,566.8071
Set Internal Change=Bald Eagle      ,Loc Hav         ,53922.53, 9 , 3 ,566.2192
Set Internal Change=Bald Eagle      ,Loc Hav         ,52879.19, 9 , 3 ,565.629
Set Internal Change=Bald Eagle      ,Loc Hav         ,51784.74, 9 , 3 ,565.0621
Set Internal Change=Bald Eagle      ,Loc Hav         ,50720.68, 9 , 3 ,564.6894
Set Internal Change=Bald Eagle      ,Loc Hav         ,49715.77, 9 , 3 ,564.4307
Set Internal Change=Bald Eagle      ,Loc Hav         ,48965.94, 9 , 3 ,564.1498
Set Internal Change=Bald Eagle      ,Loc Hav         ,48110.09, 9 , 3 ,563.1851
Set Internal Change=Bald Eagle      ,Loc Hav         ,47453.14, 9 , 3 ,562.5005
Set Internal Change=Bald Eagle      ,Loc Hav         ,46722.59, 9 , 3 ,561.9222
Set Internal Change=Bald Eagle      ,Loc Hav         ,46310.48, 9 , 3 ,561.6755
Set Internal Change=Bald Eagle      ,Loc Hav         ,45805.37, 9 , 3 ,561.4482
Set Internal Change=Bald Eagle      ,Loc Hav         ,45233.89, 9 , 3 ,561.2182
Set Internal Change=Bald Eagle      ,Loc Hav         ,44529.29, 9 , 3 ,560.8578
Set Internal Change=Bald Eagle      ,Loc Hav         ,43919.30, 9 , 3 ,560.6287
Set Internal Change=Bald Eagle      ,Loc Hav         ,42895.87, 9 , 3 ,560.0685
Set Internal Change=Bald Eagle      ,Loc Hav         ,41806.43, 9 , 3 ,559.3698
Set Internal Change=Bald Eagle      ,Loc Hav         ,40526.85, 9 , 3 ,558.7168
Set Internal Change=Bald Eagle      ,Loc Hav         ,39499.37, 9 , 3 ,558.3792
Set Internal Change=Bald Eagle      ,Loc Hav         ,38446.87, 9 , 3 ,557.9222
Set Internal Change=Bald Eagle      ,Loc Hav         ,37962.54, 9 , 3 ,557.595
Set Internal Change=Bald Eagle      ,Loc Hav         ,37385.23, 9 , 3 ,557.3715
Set Internal Change=Bald Eagle      ,Loc Hav         ,36769.88, 9 , 3 ,557.2599
Set Internal Change=Bald Eagle      ,Loc Hav         ,36663.76, 9 , 3 ,557.2086
Set Internal Change=Bald Eagle      ,Loc Hav         ,36339.56, 9 , 3 ,556.9982
Set Internal Change=Bald Eagle      ,Loc Hav         ,35648.50, 9 , 3 ,556.7186
Set Internal Change=Bald Eagle      ,Loc Hav         ,35072.37, 9 , 3 ,556.5788
Set Internal Change=Bald Eagle      ,Loc Hav         ,34098.93, 9 , 3 ,556.3105
Set Internal Change=Bald Eagle      ,Loc Hav         ,33498.68, 9 , 3 ,556.1484
Set Internal Change=Bald Eagle      ,Loc Hav         ,32195.47, 9 , 3 ,555.2595
Set Internal Change=Bald Eagle      ,Loc Hav         ,30878.12, 9 , 3 ,554.3798
Set Internal Change=Bald Eagle      ,Loc Hav         ,29563.77, 9 , 3 ,553.7578
Set Internal Change=Bald Eagle      ,Loc Hav         ,27226.40, 9 , 3 ,551.6284
Set Internal Change=Bald Eagle      ,Loc Hav         ,25960.70, 9 , 3 ,549.5803
Set Internal Change=Bald Eagle      ,Loc Hav         ,24843.25, 9 , 3 ,548.4288
Set Internal Change=Bald Eagle      ,Loc Hav         ,24417.73, 9 , 3 ,548.2397
Set Internal Change=Bald Eagle      ,Loc Hav         ,23872.06, 9 , 3 ,547.3509
Set Internal Change=Bald Eagle      ,Loc Hav         ,23783.65, 9 , 3 ,547.317
Set Internal Change=Bald Eagle      ,Loc Hav         ,23384.79, 9 , 3 ,547.094
Set Internal Change=Bald Eagle      ,Loc Hav         ,22982.97, 9 , 3 ,546.7796
Set Internal Change=Bald Eagle      ,Loc Hav         ,22386.15, 9 , 3 ,546.2406
Set Internal Change=Bald Eagle      ,Loc Hav         ,21283.34, 9 , 3 ,545.7534
Set Internal Change=Bald Eagle      ,Loc Hav         ,21199.93, 9 , 3 ,545.7466
Set Internal Change=Bald Eagle      ,Loc Hav         ,20127.30, 9 , 3 ,545.5038
Set Internal Change=Bald Eagle      ,Loc Hav         ,19036.24, 9 , 3 ,543.7903
Set Internal Change=Bald Eagle      ,Loc Hav         ,18200.10, 9 , 3 ,542.5908
Set Internal Change=Bald Eagle      ,Loc Hav         ,17549.23, 9 , 3 ,542.4022
Set Internal Change=Bald Eagle      ,Loc Hav         ,16787.45, 9 , 3 ,542.2218
Set Internal Change=Bald Eagle      ,Loc Hav         ,15407.88, 9 , 3 ,541.708
Set Internal Change=Bald Eagle      ,Loc Hav         ,14814.34, 9 , 3 ,541.3035
Set Internal Change=Bald Eagle      ,Loc Hav         ,13326.74, 9 , 3 ,540.6597
Set Internal Change=Bald Eagle      ,Loc Hav         ,12035.22, 9 , 3 ,540.3261
Set Internal Change=Bald Eagle      ,Loc Hav         ,11865.80, 9 , 3 ,540.2928
Set Internal Change=Bald Eagle      ,Loc Hav         ,11116.44, 9 , 3 ,539.8404
Set Internal Change=Bald Eagle      ,Loc Hav         ,10995.73, 9 , 3 ,539.7355
Set Internal Change=Bald Eagle      ,Loc Hav         ,10221.14, 9 , 3 ,538.8851
Set Internal Change=Bald Eagle      ,Loc Hav         ,9258.941, 9 , 3 ,538.1694
Set Internal Change=Bald Eagle      ,Loc Hav         ,8541.462, 9 , 3 ,537.9629
Set Internal Change=Bald Eagle      ,Loc Hav         ,7936.130, 9 , 3 ,537.7759
Set Internal Change=Bald Eagle      ,Loc Hav         ,6940.066, 9 , 3 ,537.2771
Set Internal Change=Bald Eagle      ,Loc Hav         ,6267.489, 9 , 3 ,536.9326
Set Internal Change=Bald Eagle      ,Loc Hav         ,5523.234, 9 , 3 ,536.6664
Set Internal Change=Bald Eagle      ,Loc Hav         ,4293.710, 9 , 3 ,536.1522
Set Internal Change=Bald Eagle      ,Loc Hav         ,3047.378, 9 , 3 ,535.3391
Set Internal Change=Bald Eagle      ,Loc Hav         ,2731.142, 9 , 3 ,534.6564
Set Internal Change=Bald Eagle      ,Loc Hav         ,2501.017, 9 , 3 ,534.4424
Set Internal Change=Bald Eagle      ,Loc Hav         ,2371.827, 9 , 3 ,534.2873
Set Internal Change=Bald Eagle      ,Loc Hav         ,1692.633, 9 , 3 ,534.0402
Set Internal Change=Bald Eagle      ,Loc Hav         ,1212.855, 9 , 3 ,533.9316
Set Internal Change=Bald Eagle      ,Loc Hav         ,659.942 , 9 , 3 ,533.3231
Set Internal Change=Bald Eagle      ,Loc Hav         ,138154.4, 10 , 3 ,667.7755
Set Internal Change=Bald Eagle      ,Loc Hav         ,137690.8, 10 , 3 ,667.4083
Set Internal Change=Bald Eagle      ,Loc Hav         ,137327.0, 10 , 3 ,666.9827
Set Internal Change=Bald Eagle      ,Loc Hav         ,136564.9, 10 , 3 ,664.1877
Set Internal Change=Bald Eagle      ,Loc Hav         ,136202.3, 10 , 3 ,663.5842
Set Internal Change=Bald Eagle      ,Loc Hav         ,135591.4, 10 , 3 ,662.2703
Set Internal Change=Bald Eagle      ,Loc Hav         ,135068.7, 10 , 3 ,661.5682
Set Internal Change=Bald Eagle      ,Loc Hav         ,134487.2, 10 , 3 ,660.4742
Set Internal Change=Bald Eagle      ,Loc Hav         ,133881.0, 10 , 3 ,659.7171
Set Internal Change=Bald Eagle      ,Loc Hav         ,133446.1, 10 , 3 ,659.1945
Set Internal Change=Bald Eagle      ,Loc Hav         ,132973.6, 10 , 3 ,658.6212
Set Internal Change=Bald Eagle      ,Loc Hav         ,132363.8, 10 , 3 ,657.39
Set Internal Change=Bald Eagle      ,Loc Hav         ,131699.7, 10 , 3 ,655.5016
Set Internal Change=Bald Eagle      ,Loc Hav         ,130997.6, 10 , 3 ,653.567
Set Internal Change=Bald Eagle      ,Loc Hav         ,130339.2, 10 , 3 ,652.0797
Set Internal Change=Bald Eagle      ,Loc Hav         ,129627.5, 10 , 3 ,650.5558
Set Internal Change=Bald Eagle      ,Loc Hav         ,128760.7, 10 , 3 ,648.8082
Set Internal Change=Bald Eagle      ,Loc Hav         ,128280.7, 10 , 3 ,648.0787
Set Internal Change=Bald Eagle      ,Loc Hav         ,127410.9, 10 , 3 ,647.2212
Set Internal Change=Bald Eagle      ,Loc Hav         ,126741.0, 10 , 3 ,646.4954
Set Internal Change=Bald Eagle      ,Loc Hav         ,126454.1, 10 , 3 ,645.9004
Set Internal Change=Bald Eagle      ,Loc Hav         ,126062.6, 10 , 3 ,645.1968
Set Internal Change=Bald Eagle      ,Loc Hav         ,125704.7, 10 , 3 ,644.6196
Set Internal Change=Bald Eagle      ,Loc Hav         ,125091.9, 10 , 3 ,643.6783
Set Internal Change=Bald Eagle      ,Loc Hav         ,124615.5, 10 , 3 ,643.2036
Set Internal Change=Bald Eagle      ,Loc Hav         ,124025.0, 10 , 3 ,641.8846
Set Internal Change=Bald Eagle      ,Loc Hav         ,123503.5, 10 , 3 ,640.8162
Set Internal Change=Bald Eagle      ,Loc Hav         ,123123.6, 10 , 3 ,640.211
Set Internal Change=Bald Eagle      ,Loc Hav         ,122703.3, 10 , 3 ,639.6808
Set Internal Change=Bald Eagle      ,Loc Hav         ,122190.8, 10 , 3 ,638.9833
Set Internal Change=Bald Eagle      ,Loc Hav         ,121754.0, 10 , 3 ,638.4722
Set Internal Change=Bald Eagle      ,Loc Hav         ,121394.1, 10 , 3 ,638.143
Set Internal Change=Bald Eagle      ,Loc Hav         ,120862.6, 10 , 3 ,637.592
Set Internal Change=Bald Eagle      ,Loc Hav         ,120421.4, 10 , 3 ,636.8324
Set Internal Change=Bald Eagle      ,Loc Hav         ,119954.9, 10 , 3 ,636.1491
Set Internal Change=Bald Eagle      ,Loc Hav         ,119473.8, 10 , 3 ,635.2328
Set Internal Change=Bald Eagle      ,Loc Hav         ,118901.0, 10 , 3 ,633.8841
Set Internal Change=Bald Eagle      ,Loc Hav         ,118300.5, 10 , 3 ,632.9473
Set Internal Change=Bald Eagle      ,Loc Hav         ,117753.9, 10 , 3 ,632.3479
Set Internal Change=Bald Eagle      ,Loc Hav         ,117180.8, 10 , 3 ,631.4971
Set Internal Change=Bald Eagle      ,Loc Hav         ,116401.3, 10 , 3 ,630.6484
Set Internal Change=Bald Eagle      ,Loc Hav         ,115584.2, 10 , 3 ,629.9286
Set Internal Change=Bald Eagle      ,Loc Hav         ,114899.8, 10 , 3 ,629.1247
Set Internal Change=Bald Eagle      ,Loc Hav         ,113985.6, 10 , 3 ,628.1086
Set Internal Change=Bald Eagle      ,Loc Hav         ,112856.9, 10 , 3 ,627.1587
Set Internal Change=Bald Eagle      ,Loc Hav         ,111971.0, 10 , 3 ,626.3627
Set Internal Change=Bald Eagle      ,Loc Hav         ,110657.4, 10 , 3 ,625.3547
Set Internal Change=Bald Eagle      ,Loc Hav         ,109659.9, 10 , 3 ,624.6366
Set Internal Change=Bald Eagle      ,Loc Hav         ,108600.1, 10 , 3 ,623.9757
Set Internal Change=Bald Eagle      ,Loc Hav         ,107333.6, 10 , 3 ,622.85
Set Internal Change=Bald Eagle      ,Loc Hav         ,106466.0, 10 , 3 ,622.1531
Set Internal Change=Bald Eagle      ,Loc Hav         ,105178.6, 10 , 3 ,621.5741
Set Internal Change=Bald Eagle      ,Loc Hav         ,104647.2, 10 , 3 ,621.1615
Set Internal Change=Bald Eagle      ,Loc Hav         ,104195.0, 10 , 3 ,620.8831
Set Internal Change=Bald Eagle      ,Loc Hav         ,103854.0, 10 , 3 ,620.7488
Set Internal Change=Bald Eagle      ,Loc Hav         ,103369.7, 10 , 3 ,620.4823
Set Internal Change=Bald Eagle      ,Loc Hav         ,103122.3, 10 , 3 ,619.4103
Set Internal Change=Bald Eagle      ,Loc Hav         ,101440.3, 10 , 3 ,617.4161
Set Internal Change=Bald Eagle      ,Loc Hav         ,100657.3, 10 , 3 ,616.754
Set Internal Change=Bald Eagle      ,Loc Hav         ,99452.75, 10 , 3 ,616.1816
Set Internal Change=Bald Eagle      ,Loc Hav         ,98206.87, 10 , 3 ,615.7616
Set Internal Change=Bald Eagle      ,Loc Hav         ,97607.35, 10 , 3 ,614.997
Set Internal Change=Bald Eagle      ,Loc Hav         ,96370.43, 10 , 3 ,614.144
Set Internal Change=Bald Eagle      ,Loc Hav         ,94560.01, 10 , 3 ,613.9244
Set Internal Change=Bald Eagle      ,Loc Hav         ,93391.71, 10 , 3 ,613.882
Set Internal Change=Bald Eagle      ,Loc Hav         ,92011.85, 10 , 3 ,613.8475
Set Internal Change=Bald Eagle      ,Loc Hav         ,91030.01, 10 , 3 ,613.8257
Set Internal Change=Bald Eagle      ,Loc Hav         ,90096.99, 10 , 3 ,613.8176
Set Internal Change=Bald Eagle      ,Loc Hav         ,89060.69, 10 , 3 ,613.8124
Set Internal Change=Bald Eagle      ,Loc Hav         ,87861.14, 10 , 3 ,613.8099
Set Internal Change=Bald Eagle      ,Loc Hav         ,86942.04, 10 , 3 ,613.8093
Set Internal Change=Bald Eagle      ,Loc Hav         ,85569.53, 10 , 3 ,613.8088
Set Internal Change=Bald Eagle      ,Loc Hav         ,84724.08, 10 , 3 ,613.8085
Set Internal Change=Bald Eagle      ,Loc Hav         ,83563.41, 10 , 3 ,613.8085
Set Internal Change=Bald Eagle      ,Loc Hav         ,82607.89, 10 , 3 ,613.8085
Set Internal Change=Bald Eagle      ,Loc Hav         ,81849.41, 10 , 3 ,613.7951
Set Internal Change=Bald Eagle      ,Loc Hav         ,81084.18, 10 , 3 ,590.9089
Set Internal Change=Bald Eagle      ,Loc Hav         ,80500.50, 10 , 3 ,589.3267
Set Internal Change=Bald Eagle      ,Loc Hav         ,79684.28, 10 , 3 ,588.5587
Set Internal Change=Bald Eagle      ,Loc Hav         ,78627.87, 10 , 3 ,588.128
Set Internal Change=Bald Eagle      ,Loc Hav         ,76643.40, 10 , 3 ,586.4009
Set Internal Change=Bald Eagle      ,Loc Hav         ,76002.96, 10 , 3 ,585.7104
Set Internal Change=Bald Eagle      ,Loc Hav         ,75917.82, 10 , 3 ,585.5825
Set Internal Change=Bald Eagle      ,Loc Hav         ,75616.14, 10 , 3 ,585.1107
Set Internal Change=Bald Eagle      ,Loc Hav         ,74650.60, 10 , 3 ,584.2349
Set Internal Change=Bald Eagle      ,Loc Hav         ,74207.96, 10 , 3 ,583.8978
Set Internal Change=Bald Eagle      ,Loc Hav         ,73504.24, 10 , 3 ,583.3147
Set Internal Change=Bald Eagle      ,Loc Hav         ,72303.68, 10 , 3 ,582.468
Set Internal Change=Bald Eagle      ,Loc Hav         ,71400.81, 10 , 3 ,581.5547
Set Internal Change=Bald Eagle      ,Loc Hav         ,70651.52, 10 , 3 ,580.8693
Set Internal Change=Bald Eagle      ,Loc Hav         ,69567.33, 10 , 3 ,579.9995
Set Internal Change=Bald Eagle      ,Loc Hav         ,68604.09, 10 , 3 ,579.4385
Set Internal Change=Bald Eagle      ,Loc Hav         ,67326.78, 10 , 3 ,578.6746
Set Internal Change=Bald Eagle      ,Loc Hav         ,66070.17, 10 , 3 ,577.6879
Set Internal Change=Bald Eagle      ,Loc Hav         ,64908.02, 10 , 3 ,576.2943
Set Internal Change=Bald Eagle      ,Loc Hav         ,63812.99, 10 , 3 ,574.8377
Set Internal Change=Bald Eagle      ,Loc Hav         ,62746.41, 10 , 3 ,573.7575
Set Internal Change=Bald Eagle      ,Loc Hav         ,61896.89, 10 , 3 ,572.9225
Set Internal Change=Bald Eagle      ,Loc Hav         ,60901.09, 10 , 3 ,571.8776
Set Internal Change=Bald Eagle      ,Loc Hav         ,59795.28, 10 , 3 ,570.829
Set Internal Change=Bald Eagle      ,Loc Hav         ,58836.23, 10 , 3 ,570.1827
Set Internal Change=Bald Eagle      ,Loc Hav         ,58708.54, 10 , 3 ,570.1118
Set Internal Change=Bald Eagle      ,Loc Hav         ,58091.91, 10 , 3 ,569.7029
Set Internal Change=Bald Eagle      ,Loc Hav         ,57700.27, 10 , 3 ,569.3479
Set Internal Change=Bald Eagle      ,Loc Hav         ,57250.60, 10 , 3 ,569.1101
Set Internal Change=Bald Eagle      ,Loc Hav         ,56775.92, 10 , 3 ,568.7324
Set Internal Change=Bald Eagle      ,Loc Hav         ,56243.79, 10 , 3 ,568.3777
Set Internal Change=Bald Eagle      ,Loc Hav         ,55700.55, 10 , 3 ,568.0238
Set Internal Change=Bald Eagle      ,Loc Hav         ,54696.51, 10 , 3 ,567.439
Set Internal Change=Bald Eagle      ,Loc Hav         ,53922.53, 10 , 3 ,566.8669
Set Internal Change=Bald Eagle      ,Loc Hav         ,52879.19, 10 , 3 ,566.2743
Set Internal Change=Bald Eagle      ,Loc Hav         ,51784.74, 10 , 3 ,565.6572
Set Internal Change=Bald Eagle      ,Loc Hav         ,50720.68, 10 , 3 ,565.2464
Set Internal Change=Bald Eagle      ,Loc Hav         ,49715.77, 10 , 3 ,564.9833
Set Internal Change=Bald Eagle      ,Loc Hav         ,48965.94, 10 , 3 ,564.6943
Set Internal Change=Bald Eagle      ,Loc Hav         ,48110.09, 10 , 3 ,563.7073
Set Internal Change=Bald Eagle      ,Loc Hav         ,47453.14, 10 , 3 ,563.0195
Set Internal Change=Bald Eagle      ,Loc Hav         ,46722.59, 10 , 3 ,562.4499
Set Internal Change=Bald Eagle      ,Loc Hav         ,46310.48, 10 , 3 ,562.209
Set Internal Change=Bald Eagle      ,Loc Hav         ,45805.37, 10 , 3 ,561.9742
Set Internal Change=Bald Eagle      ,Loc Hav         ,45233.89, 10 , 3 ,561.7209
Set Internal Change=Bald Eagle      ,Loc Hav         ,44529.29, 10 , 3 ,561.325
Set Internal Change=Bald Eagle      ,Loc Hav         ,43919.30, 10 , 3 ,561.0897
Set Internal Change=Bald Eagle      ,Loc Hav         ,42895.87, 10 , 3 ,560.5369
Set Internal Change=Bald Eagle      ,Loc Hav         ,41806.43, 10 , 3 ,559.8044
Set Internal Change=Bald Eagle      ,Loc Hav         ,40526.85, 10 , 3 ,559.1663
Set Internal Change=Bald Eagle      ,Loc Hav         ,39499.37, 10 , 3 ,558.8774
Set Internal Change=Bald Eagle      ,Loc Hav         ,38446.87, 10 , 3 ,558.4709
Set Internal Change=Bald Eagle      ,Loc Hav         ,37962.54, 10 , 3 ,558.1978
Set Internal Change=Bald Eagle      ,Loc Hav         ,37385.23, 10 , 3 ,557.9822
Set Internal Change=Bald Eagle      ,Loc Hav         ,36769.88, 10 , 3 ,557.8644
Set Internal Change=Bald Eagle      ,Loc Hav         ,36663.76, 10 , 3 ,557.8058
Set Internal Change=Bald Eagle      ,Loc Hav         ,36339.56, 10 , 3 ,557.5976
Set Internal Change=Bald Eagle      ,Loc Hav         ,35648.50, 10 , 3 ,557.3013
Set Internal Change=Bald Eagle      ,Loc Hav         ,35072.37, 10 , 3 ,557.1528
Set Internal Change=Bald Eagle      ,Loc Hav         ,34098.93, 10 , 3 ,556.911
Set Internal Change=Bald Eagle      ,Loc Hav         ,33498.68, 10 , 3 ,556.7526
Set Internal Change=Bald Eagle      ,Loc Hav         ,32195.47, 10 , 3 ,555.8535
Set Internal Change=Bald Eagle      ,Loc Hav         ,30878.12, 10 , 3 ,555.006
Set Internal Change=Bald Eagle      ,Loc Hav         ,29563.77, 10 , 3 ,554.3971
Set Internal Change=Bald Eagle      ,Loc Hav         ,27226.40, 10 , 3 ,551.9957
Set Internal Change=Bald Eagle      ,Loc Hav         ,25960.70, 10 , 3 ,549.8831
Set Internal Change=Bald Eagle      ,Loc Hav         ,24843.25, 10 , 3 ,548.7822
Set Internal Change=Bald Eagle      ,Loc Hav         ,24417.73, 10 , 3 ,548.5707
Set Internal Change=Bald Eagle      ,Loc Hav         ,23872.06, 10 , 3 ,547.7198
Set Internal Change=Bald Eagle      ,Loc Hav         ,23783.65, 10 , 3 ,547.6964
Set Internal Change=Bald Eagle      ,Loc Hav         ,23384.79, 10 , 3 ,547.4611
Set Internal Change=Bald Eagle      ,Loc Hav         ,22982.97, 10 , 3 ,547.1594
Set Internal Change=Bald Eagle      ,Loc Hav         ,22386.15, 10 , 3 ,546.6058
Set Internal Change=Bald Eagle      ,Loc Hav         ,21283.34, 10 , 3 ,546.0654
Set Internal Change=Bald Eagle      ,Loc Hav         ,21199.93, 10 , 3 ,546.0574
Set Internal Change=Bald Eagle      ,Loc Hav         ,20127.30, 10 , 3 ,545.7398
Set Internal Change=Bald Eagle      ,Loc Hav         ,19036.24, 10 , 3 ,544.1819
Set Internal Change=Bald Eagle      ,Loc Hav         ,18200.10, 10 , 3 ,543.2048
Set Internal Change=Bald Eagle      ,Loc Hav         ,17549.23, 10 , 3 ,543.0469
Set Internal Change=Bald Eagle      ,Loc Hav         ,16787.45, 10 , 3 ,542.8709
Set Internal Change=Bald Eagle      ,Loc Hav         ,15407.88, 10 , 3 ,542.3379
Set Internal Change=Bald Eagle      ,Loc Hav         ,14814.34, 10 , 3 ,541.9085
Set Internal Change=Bald Eagle      ,Loc Hav         ,13326.74, 10 , 3 ,541.2535
Set Internal Change=Bald Eagle      ,Loc Hav         ,12035.22, 10 , 3 ,540.9089
Set Internal Change=Bald Eagle      ,Loc Hav         ,11865.80, 10 , 3 ,540.8708
Set Internal Change=Bald Eagle      ,Loc Hav         ,11116.44, 10 , 3 ,540.4274
Set Internal Change=Bald Eagle      ,Loc Hav         ,10995.73, 10 , 3 ,540.3359
Set Internal Change=Bald Eagle      ,Loc Hav         ,10221.14, 10 , 3 ,539.5724
Set Internal Change=Bald Eagle      ,Loc Hav         ,9258.941, 10 , 3 ,538.9135
Set Internal Change=Bald Eagle      ,Loc Hav         ,8541.462, 10 , 3 ,538.7158
Set Internal Change=Bald Eagle      ,Loc Hav         ,7936.130, 10 , 3 ,538.5326
Set Internal Change=Bald Eagle      ,Loc Hav         ,6940.066, 10 , 3 ,538.0563
Set Internal Change=Bald Eagle      ,Loc Hav         ,6267.489, 10 , 3 ,537.736
Set Internal Change=Bald Eagle      ,Loc Hav         ,5523.234, 10 , 3 ,537.487
Set Internal Change=Bald Eagle      ,Loc Hav         ,4293.710, 10 , 3 ,536.9559
Set Internal Change=Bald Eagle      ,Loc Hav         ,3047.378, 10 , 3 ,536.0348
Set Internal Change=Bald Eagle      ,Loc Hav         ,2731.142, 10 , 3 ,535.4052
Set Internal Change=Bald Eagle      ,Loc Hav         ,2501.017, 10 , 3 ,535.2478
Set Internal Change=Bald Eagle      ,Loc Hav         ,2371.827, 10 , 3 ,535.154
Set Internal Change=Bald Eagle      ,Loc Hav         ,1692.633, 10 , 3 ,534.9793
Set Internal Change=Bald Eagle      ,Loc Hav         ,1212.855, 10 , 3 ,534.8864
Set Internal Change=Bald Eagle      ,Loc Hav         ,659.942 , 10 , 3 ,534.5791
Set Internal Change=Bald Eagle      ,Loc Hav         ,138154.4, 11 , 3 ,668.3174
Set Internal Change=Bald Eagle      ,Loc Hav         ,137690.8, 11 , 3 ,667.9733
Set Internal Change=Bald Eagle      ,Loc Hav         ,137327.0, 11 , 3 ,667.5442
Set Internal Change=Bald Eagle      ,Loc Hav         ,136564.9, 11 , 3 ,664.6816
Set Internal Change=Bald Eagle      ,Loc Hav         ,136202.3, 11 , 3 ,664.0974
Set Internal Change=Bald Eagle      ,Loc Hav         ,135591.4, 11 , 3 ,662.7247
Set Internal Change=Bald Eagle      ,Loc Hav         ,135068.7, 11 , 3 ,662.0398
Set Internal Change=Bald Eagle      ,Loc Hav         ,134487.2, 11 , 3 ,660.9697
Set Internal Change=Bald Eagle      ,Loc Hav         ,133881.0, 11 , 3 ,660.2223
Set Internal Change=Bald Eagle      ,Loc Hav         ,133446.1, 11 , 3 ,659.6888
Set Internal Change=Bald Eagle      ,Loc Hav         ,132973.6, 11 , 3 ,659.1104
Set Internal Change=Bald Eagle      ,Loc Hav         ,132363.8, 11 , 3 ,657.8252
Set Internal Change=Bald Eagle      ,Loc Hav         ,131699.7, 11 , 3 ,655.8941
Set Internal Change=Bald Eagle      ,Loc Hav         ,130997.6, 11 , 3 ,653.9321
Set Internal Change=Bald Eagle      ,Loc Hav         ,130339.2, 11 , 3 ,652.4182
Set Internal Change=Bald Eagle      ,Loc Hav         ,129627.5, 11 , 3 ,650.8762
Set Internal Change=Bald Eagle      ,Loc Hav         ,128760.7, 11 , 3 ,649.17
Set Internal Change=Bald Eagle      ,Loc Hav         ,128280.7, 11 , 3 ,648.4974
Set Internal Change=Bald Eagle      ,Loc Hav         ,127410.9, 11 , 3 ,647.7006
Set Internal Change=Bald Eagle      ,Loc Hav         ,126741.0, 11 , 3 ,646.9781
Set Internal Change=Bald Eagle      ,Loc Hav         ,126454.1, 11 , 3 ,646.3671
Set Internal Change=Bald Eagle      ,Loc Hav         ,126062.6, 11 , 3 ,645.6473
Set Internal Change=Bald Eagle      ,Loc Hav         ,125704.7, 11 , 3 ,645.0684
Set Internal Change=Bald Eagle      ,Loc Hav         ,125091.9, 11 , 3 ,644.1375
Set Internal Change=Bald Eagle      ,Loc Hav         ,124615.5, 11 , 3 ,643.6647
Set Internal Change=Bald Eagle      ,Loc Hav         ,124025.0, 11 , 3 ,642.3461
Set Internal Change=Bald Eagle      ,Loc Hav         ,123503.5, 11 , 3 ,641.3084
Set Internal Change=Bald Eagle      ,Loc Hav         ,123123.6, 11 , 3 ,640.7213
Set Internal Change=Bald Eagle      ,Loc Hav         ,122703.3, 11 , 3 ,640.1962
Set Internal Change=Bald Eagle      ,Loc Hav         ,122190.8, 11 , 3 ,639.5067
Set Internal Change=Bald Eagle      ,Loc Hav         ,121754.0, 11 , 3 ,638.9927
Set Internal Change=Bald Eagle      ,Loc Hav         ,121394.1, 11 , 3 ,638.6577
Set Internal Change=Bald Eagle      ,Loc Hav         ,120862.6, 11 , 3 ,638.1024
Set Internal Change=Bald Eagle      ,Loc Hav         ,120421.4, 11 , 3 ,637.335
Set Internal Change=Bald Eagle      ,Loc Hav         ,119954.9, 11 , 3 ,636.6324
Set Internal Change=Bald Eagle      ,Loc Hav         ,119473.8, 11 , 3 ,635.7106
Set Internal Change=Bald Eagle      ,Loc Hav         ,118901.0, 11 , 3 ,634.3688
Set Internal Change=Bald Eagle      ,Loc Hav         ,118300.5, 11 , 3 ,633.4007
Set Internal Change=Bald Eagle      ,Loc Hav         ,117753.9, 11 , 3 ,632.7712
Set Internal Change=Bald Eagle      ,Loc Hav         ,117180.8, 11 , 3 ,631.8762
Set Internal Change=Bald Eagle      ,Loc Hav         ,116401.3, 11 , 3 ,631.0169
Set Internal Change=Bald Eagle      ,Loc Hav         ,115584.2, 11 , 3 ,630.2994
Set Internal Change=Bald Eagle      ,Loc Hav         ,114899.8, 11 , 3 ,629.5093
Set Internal Change=Bald Eagle      ,Loc Hav         ,113985.6, 11 , 3 ,628.5178
Set Internal Change=Bald Eagle      ,Loc Hav         ,112856.9, 11 , 3 ,627.5654
Set Internal Change=Bald Eagle      ,Loc Hav         ,111971.0, 11 , 3 ,626.8086
Set Internal Change=Bald Eagle      ,Loc Hav         ,110657.4, 11 , 3 ,625.843
Set Internal Change=Bald Eagle      ,Loc Hav         ,109659.9, 11 , 3 ,625.1069
Set Internal Change=Bald Eagle      ,Loc Hav         ,108600.1, 11 , 3 ,624.423
Set Internal Change=Bald Eagle      ,Loc Hav         ,107333.6, 11 , 3 ,623.4113
Set Internal Change=Bald Eagle      ,Loc Hav         ,106466.0, 11 , 3 ,622.8087
Set Internal Change=Bald Eagle      ,Loc Hav         ,105178.6, 11 , 3 ,622.287
Set Internal Change=Bald Eagle      ,Loc Hav         ,104647.2, 11 , 3 ,621.9088
Set Internal Change=Bald Eagle      ,Loc Hav         ,104195.0, 11 , 3 ,621.658
Set Internal Change=Bald Eagle      ,Loc Hav         ,103854.0, 11 , 3 ,621.5372
Set Internal Change=Bald Eagle      ,Loc Hav         ,103369.7, 11 , 3 ,621.2964
Set Internal Change=Bald Eagle      ,Loc Hav         ,103122.3, 11 , 3 ,620.2903
Set Internal Change=Bald Eagle      ,Loc Hav         ,101440.3, 11 , 3 ,618.8788
Set Internal Change=Bald Eagle      ,Loc Hav         ,100657.3, 11 , 3 ,618.547
Set Internal Change=Bald Eagle      ,Loc Hav         ,99452.75, 11 , 3 ,618.3052
Set Internal Change=Bald Eagle      ,Loc Hav         ,98206.87, 11 , 3 ,618.1537
Set Internal Change=Bald Eagle      ,Loc Hav         ,97607.35, 11 , 3 ,617.8993
Set Internal Change=Bald Eagle      ,Loc Hav         ,96370.43, 11 , 3 ,617.6833
Set Internal Change=Bald Eagle      ,Loc Hav         ,94560.01, 11 , 3 ,617.6325
Set Internal Change=Bald Eagle      ,Loc Hav         ,93391.71, 11 , 3 ,617.6168
Set Internal Change=Bald Eagle      ,Loc Hav         ,92011.85, 11 , 3 ,617.6017
Set Internal Change=Bald Eagle      ,Loc Hav         ,91030.01, 11 , 3 ,617.5918
Set Internal Change=Bald Eagle      ,Loc Hav         ,90096.99, 11 , 3 ,617.5891
Set Internal Change=Bald Eagle      ,Loc Hav         ,89060.69, 11 , 3 ,617.5866
Set Internal Change=Bald Eagle      ,Loc Hav         ,87861.14, 11 , 3 ,617.5854
Set Internal Change=Bald Eagle      ,Loc Hav         ,86942.04, 11 , 3 ,617.5853
Set Internal Change=Bald Eagle      ,Loc Hav         ,85569.53, 11 , 3 ,617.5851
Set Internal Change=Bald Eagle      ,Loc Hav         ,84724.08, 11 , 3 ,617.585
Set Internal Change=Bald Eagle      ,Loc Hav         ,83563.41, 11 , 3 ,617.585
Set Internal Change=Bald Eagle      ,Loc Hav         ,82607.89, 11 , 3 ,617.585
Set Internal Change=Bald Eagle      ,Loc Hav         ,81849.41, 11 , 3 ,617.5815
Set Internal Change=Bald Eagle      ,Loc Hav         ,81084.18, 11 , 3 ,591.3006
Set Internal Change=Bald Eagle      ,Loc Hav         ,80500.50, 11 , 3 ,589.6609
Set Internal Change=Bald Eagle      ,Loc Hav         ,79684.28, 11 , 3 ,588.8257
Set Internal Change=Bald Eagle      ,Loc Hav         ,78627.87, 11 , 3 ,588.328
Set Internal Change=Bald Eagle      ,Loc Hav         ,76643.40, 11 , 3 ,586.7873
Set Internal Change=Bald Eagle      ,Loc Hav         ,76002.96, 11 , 3 ,586.1359
Set Internal Change=Bald Eagle      ,Loc Hav         ,75917.82, 11 , 3 ,586.0131
Set Internal Change=Bald Eagle      ,Loc Hav         ,75616.14, 11 , 3 ,585.5523
Set Internal Change=Bald Eagle      ,Loc Hav         ,74650.60, 11 , 3 ,584.6816
Set Internal Change=Bald Eagle      ,Loc Hav         ,74207.96, 11 , 3 ,584.3458
Set Internal Change=Bald Eagle      ,Loc Hav         ,73504.24, 11 , 3 ,583.7816
Set Internal Change=Bald Eagle      ,Loc Hav         ,72303.68, 11 , 3 ,582.9689
Set Internal Change=Bald Eagle      ,Loc Hav         ,71400.81, 11 , 3 ,582.04
Set Internal Change=Bald Eagle      ,Loc Hav         ,70651.52, 11 , 3 ,581.3191
Set Internal Change=Bald Eagle      ,Loc Hav         ,69567.33, 11 , 3 ,580.428
Set Internal Change=Bald Eagle      ,Loc Hav         ,68604.09, 11 , 3 ,579.8652
Set Internal Change=Bald Eagle      ,Loc Hav         ,67326.78, 11 , 3 ,579.0629
Set Internal Change=Bald Eagle      ,Loc Hav         ,66070.17, 11 , 3 ,578.0054
Set Internal Change=Bald Eagle      ,Loc Hav         ,64908.02, 11 , 3 ,576.6583
Set Internal Change=Bald Eagle      ,Loc Hav         ,63812.99, 11 , 3 ,575.2379
Set Internal Change=Bald Eagle      ,Loc Hav         ,62746.41, 11 , 3 ,574.1659
Set Internal Change=Bald Eagle      ,Loc Hav         ,61896.89, 11 , 3 ,573.3685
Set Internal Change=Bald Eagle      ,Loc Hav         ,60901.09, 11 , 3 ,572.334
Set Internal Change=Bald Eagle      ,Loc Hav         ,59795.28, 11 , 3 ,571.3054
Set Internal Change=Bald Eagle      ,Loc Hav         ,58836.23, 11 , 3 ,570.6609
Set Internal Change=Bald Eagle      ,Loc Hav         ,58708.54, 11 , 3 ,570.5873
Set Internal Change=Bald Eagle      ,Loc Hav         ,58091.91, 11 , 3 ,570.2144
Set Internal Change=Bald Eagle      ,Loc Hav         ,57700.27, 11 , 3 ,569.8854
Set Internal Change=Bald Eagle      ,Loc Hav         ,57250.60, 11 , 3 ,569.6455
Set Internal Change=Bald Eagle      ,Loc Hav         ,56775.92, 11 , 3 ,569.265
Set Internal Change=Bald Eagle      ,Loc Hav         ,56243.79, 11 , 3 ,568.9428
Set Internal Change=Bald Eagle      ,Loc Hav         ,55700.55, 11 , 3 ,568.5931
Set Internal Change=Bald Eagle      ,Loc Hav         ,54696.51, 11 , 3 ,568.0117
Set Internal Change=Bald Eagle      ,Loc Hav         ,53922.53, 11 , 3 ,567.4401
Set Internal Change=Bald Eagle      ,Loc Hav         ,52879.19, 11 , 3 ,566.8077
Set Internal Change=Bald Eagle      ,Loc Hav         ,51784.74, 11 , 3 ,566.1137
Set Internal Change=Bald Eagle      ,Loc Hav         ,50720.68, 11 , 3 ,565.6605
Set Internal Change=Bald Eagle      ,Loc Hav         ,49715.77, 11 , 3 ,565.4255
Set Internal Change=Bald Eagle      ,Loc Hav         ,48965.94, 11 , 3 ,565.1436
Set Internal Change=Bald Eagle      ,Loc Hav         ,48110.09, 11 , 3 ,564.145
Set Internal Change=Bald Eagle      ,Loc Hav         ,47453.14, 11 , 3 ,563.4515
Set Internal Change=Bald Eagle      ,Loc Hav         ,46722.59, 11 , 3 ,562.8748
Set Internal Change=Bald Eagle      ,Loc Hav         ,46310.48, 11 , 3 ,562.6301
Set Internal Change=Bald Eagle      ,Loc Hav         ,45805.37, 11 , 3 ,562.3838
Set Internal Change=Bald Eagle      ,Loc Hav         ,45233.89, 11 , 3 ,562.1238
Set Internal Change=Bald Eagle      ,Loc Hav         ,44529.29, 11 , 3 ,561.7147
Set Internal Change=Bald Eagle      ,Loc Hav         ,43919.30, 11 , 3 ,561.4728
Set Internal Change=Bald Eagle      ,Loc Hav         ,42895.87, 11 , 3 ,560.9126
Set Internal Change=Bald Eagle      ,Loc Hav         ,41806.43, 11 , 3 ,560.1891
Set Internal Change=Bald Eagle      ,Loc Hav         ,40526.85, 11 , 3 ,559.6387
Set Internal Change=Bald Eagle      ,Loc Hav         ,39499.37, 11 , 3 ,559.4116
Set Internal Change=Bald Eagle      ,Loc Hav         ,38446.87, 11 , 3 ,559.0482
Set Internal Change=Bald Eagle      ,Loc Hav         ,37962.54, 11 , 3 ,558.8124
Set Internal Change=Bald Eagle      ,Loc Hav         ,37385.23, 11 , 3 ,558.6046
Set Internal Change=Bald Eagle      ,Loc Hav         ,36769.88, 11 , 3 ,558.4806
Set Internal Change=Bald Eagle      ,Loc Hav         ,36663.76, 11 , 3 ,558.4165
Set Internal Change=Bald Eagle      ,Loc Hav         ,36339.56, 11 , 3 ,558.2098
Set Internal Change=Bald Eagle      ,Loc Hav         ,35648.50, 11 , 3 ,557.8982
Set Internal Change=Bald Eagle      ,Loc Hav         ,35072.37, 11 , 3 ,557.7415
Set Internal Change=Bald Eagle      ,Loc Hav         ,34098.93, 11 , 3 ,557.5074
Set Internal Change=Bald Eagle      ,Loc Hav         ,33498.68, 11 , 3 ,557.3434
Set Internal Change=Bald Eagle      ,Loc Hav         ,32195.47, 11 , 3 ,556.4708
Set Internal Change=Bald Eagle      ,Loc Hav         ,30878.12, 11 , 3 ,555.6482
Set Internal Change=Bald Eagle      ,Loc Hav         ,29563.77, 11 , 3 ,555.0336
Set Internal Change=Bald Eagle      ,Loc Hav         ,27226.40, 11 , 3 ,552.3767
Set Internal Change=Bald Eagle      ,Loc Hav         ,25960.70, 11 , 3 ,550.1943
Set Internal Change=Bald Eagle      ,Loc Hav         ,24843.25, 11 , 3 ,549.1332
Set Internal Change=Bald Eagle      ,Loc Hav         ,24417.73, 11 , 3 ,548.9014
Set Internal Change=Bald Eagle      ,Loc Hav         ,23872.06, 11 , 3 ,548.0593
Set Internal Change=Bald Eagle      ,Loc Hav         ,23783.65, 11 , 3 ,548.0389
Set Internal Change=Bald Eagle      ,Loc Hav         ,23384.79, 11 , 3 ,547.7915
Set Internal Change=Bald Eagle      ,Loc Hav         ,22982.97, 11 , 3 ,547.4905
Set Internal Change=Bald Eagle      ,Loc Hav         ,22386.15, 11 , 3 ,546.944
Set Internal Change=Bald Eagle      ,Loc Hav         ,21283.34, 11 , 3 ,546.4045
Set Internal Change=Bald Eagle      ,Loc Hav         ,21199.93, 11 , 3 ,546.3935
Set Internal Change=Bald Eagle      ,Loc Hav         ,20127.30, 11 , 3 ,546.021
Set Internal Change=Bald Eagle      ,Loc Hav         ,19036.24, 11 , 3 ,544.5565
Set Internal Change=Bald Eagle      ,Loc Hav         ,18200.10, 11 , 3 ,543.7006
Set Internal Change=Bald Eagle      ,Loc Hav         ,17549.23, 11 , 3 ,543.5499
Set Internal Change=Bald Eagle      ,Loc Hav         ,16787.45, 11 , 3 ,543.3702
Set Internal Change=Bald Eagle      ,Loc Hav         ,15407.88, 11 , 3 ,542.8401
Set Internal Change=Bald Eagle      ,Loc Hav         ,14814.34, 11 , 3 ,542.4005
Set Internal Change=Bald Eagle      ,Loc Hav         ,13326.74, 11 , 3 ,541.7465
Set Internal Change=Bald Eagle      ,Loc Hav         ,12035.22, 11 , 3 ,541.395
Set Internal Change=Bald Eagle      ,Loc Hav         ,11865.80, 11 , 3 ,541.3541
Set Internal Change=Bald Eagle      ,Loc Hav         ,11116.44, 11 , 3 ,540.9168
Set Internal Change=Bald Eagle      ,Loc Hav         ,10995.73, 11 , 3 ,540.8325
Set Internal Change=Bald Eagle      ,Loc Hav         ,10221.14, 11 , 3 ,540.0973
Set Internal Change=Bald Eagle      ,Loc Hav         ,9258.941, 11 , 3 ,539.467
Set Internal Change=Bald Eagle      ,Loc Hav         ,8541.462, 11 , 3 ,539.2812
Set Internal Change=Bald Eagle      ,Loc Hav         ,7936.130, 11 , 3 ,539.0941
Set Internal Change=Bald Eagle      ,Loc Hav         ,6940.066, 11 , 3 ,538.6376
Set Internal Change=Bald Eagle      ,Loc Hav         ,6267.489, 11 , 3 ,538.3386
Set Internal Change=Bald Eagle      ,Loc Hav         ,5523.234, 11 , 3 ,538.0909
Set Internal Change=Bald Eagle      ,Loc Hav         ,4293.710, 11 , 3 ,537.5557
Set Internal Change=Bald Eagle      ,Loc Hav         ,3047.378, 11 , 3 ,536.7787
Set Internal Change=Bald Eagle      ,Loc Hav         ,2731.142, 11 , 3 ,536.3668
Set Internal Change=Bald Eagle      ,Loc Hav         ,2501.017, 11 , 3 ,536.2687
Set Internal Change=Bald Eagle      ,Loc Hav         ,2371.827, 11 , 3 ,536.2126
Set Internal Change=Bald Eagle      ,Loc Hav         ,1692.633, 11 , 3 ,536.0919
Set Internal Change=Bald Eagle      ,Loc Hav         ,1212.855, 11 , 3 ,536.0208
Set Internal Change=Bald Eagle      ,Loc Hav         ,659.942 , 11 , 3 ,535.8525
Set Internal Change=Bald Eagle      ,Loc Hav         ,138154.4, 12 , 3 ,668.8256
Set Internal Change=Bald Eagle      ,Loc Hav         ,137690.8, 12 , 3 ,668.4996
Set Internal Change=Bald Eagle      ,Loc Hav         ,137327.0, 12 , 3 ,668.0618
Set Internal Change=Bald Eagle      ,Loc Hav         ,136564.9, 12 , 3 ,665.1371
Set Internal Change=Bald Eagle      ,Loc Hav         ,136202.3, 12 , 3 ,664.5719
Set Internal Change=Bald Eagle      ,Loc Hav         ,135591.4, 12 , 3 ,663.1554
Set Internal Change=Bald Eagle      ,Loc Hav         ,135068.7, 12 , 3 ,662.4953
Set Internal Change=Bald Eagle      ,Loc Hav         ,134487.2, 12 , 3 ,661.4321
Set Internal Change=Bald Eagle      ,Loc Hav         ,133881.0, 12 , 3 ,660.6874
Set Internal Change=Bald Eagle      ,Loc Hav         ,133446.1, 12 , 3 ,660.1475
Set Internal Change=Bald Eagle      ,Loc Hav         ,132973.6, 12 , 3 ,659.5745
Set Internal Change=Bald Eagle      ,Loc Hav         ,132363.8, 12 , 3 ,658.2459
Set Internal Change=Bald Eagle      ,Loc Hav         ,131699.7, 12 , 3 ,656.2453
Set Internal Change=Bald Eagle      ,Loc Hav         ,130997.6, 12 , 3 ,654.2665
Set Internal Change=Bald Eagle      ,Loc Hav         ,130339.2, 12 , 3 ,652.7602
Set Internal Change=Bald Eagle      ,Loc Hav         ,129627.5, 12 , 3 ,651.2106
Set Internal Change=Bald Eagle      ,Loc Hav         ,128760.7, 12 , 3 ,649.5515
Set Internal Change=Bald Eagle      ,Loc Hav         ,128280.7, 12 , 3 ,648.9257
Set Internal Change=Bald Eagle      ,Loc Hav         ,127410.9, 12 , 3 ,648.172
Set Internal Change=Bald Eagle      ,Loc Hav         ,126741.0, 12 , 3 ,647.4478
Set Internal Change=Bald Eagle      ,Loc Hav         ,126454.1, 12 , 3 ,646.8257
Set Internal Change=Bald Eagle      ,Loc Hav         ,126062.6, 12 , 3 ,646.0949
Set Internal Change=Bald Eagle      ,Loc Hav         ,125704.7, 12 , 3 ,645.5147
Set Internal Change=Bald Eagle      ,Loc Hav         ,125091.9, 12 , 3 ,644.5911
Set Internal Change=Bald Eagle      ,Loc Hav         ,124615.5, 12 , 3 ,644.1207
Set Internal Change=Bald Eagle      ,Loc Hav         ,124025.0, 12 , 3 ,642.803
Set Internal Change=Bald Eagle      ,Loc Hav         ,123503.5, 12 , 3 ,641.783
Set Internal Change=Bald Eagle      ,Loc Hav         ,123123.6, 12 , 3 ,641.2073
Set Internal Change=Bald Eagle      ,Loc Hav         ,122703.3, 12 , 3 ,640.683
Set Internal Change=Bald Eagle      ,Loc Hav         ,122190.8, 12 , 3 ,639.99
Set Internal Change=Bald Eagle      ,Loc Hav         ,121754.0, 12 , 3 ,639.481
Set Internal Change=Bald Eagle      ,Loc Hav         ,121394.1, 12 , 3 ,639.1475
Set Internal Change=Bald Eagle      ,Loc Hav         ,120862.6, 12 , 3 ,638.5881
Set Internal Change=Bald Eagle      ,Loc Hav         ,120421.4, 12 , 3 ,637.8079
Set Internal Change=Bald Eagle      ,Loc Hav         ,119954.9, 12 , 3 ,637.084
Set Internal Change=Bald Eagle      ,Loc Hav         ,119473.8, 12 , 3 ,636.1459
Set Internal Change=Bald Eagle      ,Loc Hav         ,118901.0, 12 , 3 ,634.8068
Set Internal Change=Bald Eagle      ,Loc Hav         ,118300.5, 12 , 3 ,633.8341
Set Internal Change=Bald Eagle      ,Loc Hav         ,117753.9, 12 , 3 ,633.173
Set Internal Change=Bald Eagle      ,Loc Hav         ,117180.8, 12 , 3 ,632.2455
Set Internal Change=Bald Eagle      ,Loc Hav         ,116401.3, 12 , 3 ,631.3864
Set Internal Change=Bald Eagle      ,Loc Hav         ,115584.2, 12 , 3 ,630.6705
Set Internal Change=Bald Eagle      ,Loc Hav         ,114899.8, 12 , 3 ,629.89
Set Internal Change=Bald Eagle      ,Loc Hav         ,113985.6, 12 , 3 ,628.9299
Set Internal Change=Bald Eagle      ,Loc Hav         ,112856.9, 12 , 3 ,627.9998
Set Internal Change=Bald Eagle      ,Loc Hav         ,111971.0, 12 , 3 ,627.2869
Set Internal Change=Bald Eagle      ,Loc Hav         ,110657.4, 12 , 3 ,626.3915
Set Internal Change=Bald Eagle      ,Loc Hav         ,109659.9, 12 , 3 ,625.6868
Set Internal Change=Bald Eagle      ,Loc Hav         ,108600.1, 12 , 3 ,625.0315
Set Internal Change=Bald Eagle      ,Loc Hav         ,107333.6, 12 , 3 ,624.2064
Set Internal Change=Bald Eagle      ,Loc Hav         ,106466.0, 12 , 3 ,623.754
Set Internal Change=Bald Eagle      ,Loc Hav         ,105178.6, 12 , 3 ,623.3842
Set Internal Change=Bald Eagle      ,Loc Hav         ,104647.2, 12 , 3 ,623.1451
Set Internal Change=Bald Eagle      ,Loc Hav         ,104195.0, 12 , 3 ,622.9855
Set Internal Change=Bald Eagle      ,Loc Hav         ,103854.0, 12 , 3 ,622.9003
Set Internal Change=Bald Eagle      ,Loc Hav         ,103369.7, 12 , 3 ,622.7298
Set Internal Change=Bald Eagle      ,Loc Hav         ,103122.3, 12 , 3 ,622.0999
Set Internal Change=Bald Eagle      ,Loc Hav         ,101440.3, 12 , 3 ,621.5242
Set Internal Change=Bald Eagle      ,Loc Hav         ,100657.3, 12 , 3 ,621.4064
Set Internal Change=Bald Eagle      ,Loc Hav         ,99452.75, 12 , 3 ,621.3268
Set Internal Change=Bald Eagle      ,Loc Hav         ,98206.87, 12 , 3 ,621.2794
Set Internal Change=Bald Eagle      ,Loc Hav         ,97607.35, 12 , 3 ,621.1845
Set Internal Change=Bald Eagle      ,Loc Hav         ,96370.43, 12 , 3 ,621.1188
Set Internal Change=Bald Eagle      ,Loc Hav         ,94560.01, 12 , 3 ,621.0977
Set Internal Change=Bald Eagle      ,Loc Hav         ,93391.71, 12 , 3 ,621.0894
Set Internal Change=Bald Eagle      ,Loc Hav         ,92011.85, 12 , 3 ,621.0807
Set Internal Change=Bald Eagle      ,Loc Hav         ,91030.01, 12 , 3 ,621.0748
Set Internal Change=Bald Eagle      ,Loc Hav         ,90096.99, 12 , 3 ,621.0734
Set Internal Change=Bald Eagle      ,Loc Hav         ,89060.69, 12 , 3 ,621.0714
Set Internal Change=Bald Eagle      ,Loc Hav         ,87861.14, 12 , 3 ,621.0706
Set Internal Change=Bald Eagle      ,Loc Hav         ,86942.04, 12 , 3 ,621.0709
Set Internal Change=Bald Eagle      ,Loc Hav         ,85569.53, 12 , 3 ,621.0715
Set Internal Change=Bald Eagle      ,Loc Hav         ,84724.08, 12 , 3 ,621.0715
Set Internal Change=Bald Eagle      ,Loc Hav         ,83563.41, 12 , 3 ,621.0717
Set Internal Change=Bald Eagle      ,Loc Hav         ,82607.89, 12 , 3 ,621.0717
Set Internal Change=Bald Eagle      ,Loc Hav         ,81849.41, 12 , 3 ,621.0701
Set Internal Change=Bald Eagle      ,Loc Hav         ,81084.18, 12 , 3 ,591.678
Set Internal Change=Bald Eagle      ,Loc Hav         ,80500.50, 12 , 3 ,590.0084
Set Internal Change=Bald Eagle      ,Loc Hav         ,79684.28, 12 , 3 ,589.1402
Set Internal Change=Bald Eagle      ,Loc Hav         ,78627.87, 12 , 3 ,588.592
Set Internal Change=Bald Eagle      ,Loc Hav         ,76643.40, 12 , 3 ,587.1321
Set Internal Change=Bald Eagle      ,Loc Hav         ,76002.96, 12 , 3 ,586.5029
Set Internal Change=Bald Eagle      ,Loc Hav         ,75917.82, 12 , 3 ,586.382
Set Internal Change=Bald Eagle      ,Loc Hav         ,75616.14, 12 , 3 ,585.9111
Set Internal Change=Bald Eagle      ,Loc Hav         ,74650.60, 12 , 3 ,584.9958
Set Internal Change=Bald Eagle      ,Loc Hav         ,74207.96, 12 , 3 ,584.632
Set Internal Change=Bald Eagle      ,Loc Hav         ,73504.24, 12 , 3 ,584.0393
Set Internal Change=Bald Eagle      ,Loc Hav         ,72303.68, 12 , 3 ,583.2523
Set Internal Change=Bald Eagle      ,Loc Hav         ,71400.81, 12 , 3 ,582.3713
Set Internal Change=Bald Eagle      ,Loc Hav         ,70651.52, 12 , 3 ,581.6581
Set Internal Change=Bald Eagle      ,Loc Hav         ,69567.33, 12 , 3 ,580.7711
Set Internal Change=Bald Eagle      ,Loc Hav         ,68604.09, 12 , 3 ,580.1842
Set Internal Change=Bald Eagle      ,Loc Hav         ,67326.78, 12 , 3 ,579.4098
Set Internal Change=Bald Eagle      ,Loc Hav         ,66070.17, 12 , 3 ,578.3264
Set Internal Change=Bald Eagle      ,Loc Hav         ,64908.02, 12 , 3 ,577.0083
Set Internal Change=Bald Eagle      ,Loc Hav         ,63812.99, 12 , 3 ,575.6082
Set Internal Change=Bald Eagle      ,Loc Hav         ,62746.41, 12 , 3 ,574.5392
Set Internal Change=Bald Eagle      ,Loc Hav         ,61896.89, 12 , 3 ,573.7627
Set Internal Change=Bald Eagle      ,Loc Hav         ,60901.09, 12 , 3 ,572.7205
Set Internal Change=Bald Eagle      ,Loc Hav         ,59795.28, 12 , 3 ,571.7301
Set Internal Change=Bald Eagle      ,Loc Hav         ,58836.23, 12 , 3 ,571.0983
Set Internal Change=Bald Eagle      ,Loc Hav         ,58708.54, 12 , 3 ,571.0225
Set Internal Change=Bald Eagle      ,Loc Hav         ,58091.91, 12 , 3 ,570.6733
Set Internal Change=Bald Eagle      ,Loc Hav         ,57700.27, 12 , 3 ,570.3585
Set Internal Change=Bald Eagle      ,Loc Hav         ,57250.60, 12 , 3 ,570.1171
Set Internal Change=Bald Eagle      ,Loc Hav         ,56775.92, 12 , 3 ,569.7309
Set Internal Change=Bald Eagle      ,Loc Hav         ,56243.79, 12 , 3 ,569.4246
Set Internal Change=Bald Eagle      ,Loc Hav         ,55700.55, 12 , 3 ,569.0743
Set Internal Change=Bald Eagle      ,Loc Hav         ,54696.51, 12 , 3 ,568.4853
Set Internal Change=Bald Eagle      ,Loc Hav         ,53922.53, 12 , 3 ,567.8959
Set Internal Change=Bald Eagle      ,Loc Hav         ,52879.19, 12 , 3 ,567.2128
Set Internal Change=Bald Eagle      ,Loc Hav         ,51784.74, 12 , 3 ,566.4611
Set Internal Change=Bald Eagle      ,Loc Hav         ,50720.68, 12 , 3 ,565.987
Set Internal Change=Bald Eagle      ,Loc Hav         ,49715.77, 12 , 3 ,565.7664
Set Internal Change=Bald Eagle      ,Loc Hav         ,48965.94, 12 , 3 ,565.524
Set Internal Change=Bald Eagle      ,Loc Hav         ,48110.09, 12 , 3 ,564.4886
Set Internal Change=Bald Eagle      ,Loc Hav         ,47453.14, 12 , 3 ,563.7673
Set Internal Change=Bald Eagle      ,Loc Hav         ,46722.59, 12 , 3 ,563.1606
Set Internal Change=Bald Eagle      ,Loc Hav         ,46310.48, 12 , 3 ,562.9129
Set Internal Change=Bald Eagle      ,Loc Hav         ,45805.37, 12 , 3 ,562.6622
Set Internal Change=Bald Eagle      ,Loc Hav         ,45233.89, 12 , 3 ,562.3909
Set Internal Change=Bald Eagle      ,Loc Hav         ,44529.29, 12 , 3 ,561.9916
Set Internal Change=Bald Eagle      ,Loc Hav         ,43919.30, 12 , 3 ,561.7459
Set Internal Change=Bald Eagle      ,Loc Hav         ,42895.87, 12 , 3 ,561.1707
Set Internal Change=Bald Eagle      ,Loc Hav         ,41806.43, 12 , 3 ,560.5084
Set Internal Change=Bald Eagle      ,Loc Hav         ,40526.85, 12 , 3 ,560.0701
Set Internal Change=Bald Eagle      ,Loc Hav         ,39499.37, 12 , 3 ,559.8712
Set Internal Change=Bald Eagle      ,Loc Hav         ,38446.87, 12 , 3 ,559.5241
Set Internal Change=Bald Eagle      ,Loc Hav         ,37962.54, 12 , 3 ,559.3006
Set Internal Change=Bald Eagle      ,Loc Hav         ,37385.23, 12 , 3 ,559.0902
Set Internal Change=Bald Eagle      ,Loc Hav         ,36769.88, 12 , 3 ,558.9563
Set Internal Change=Bald Eagle      ,Loc Hav         ,36663.76, 12 , 3 ,558.8878
Set Internal Change=Bald Eagle      ,Loc Hav         ,36339.56, 12 , 3 ,558.6743
Set Internal Change=Bald Eagle      ,Loc Hav         ,35648.50, 12 , 3 ,558.3395
Set Internal Change=Bald Eagle      ,Loc Hav         ,35072.37, 12 , 3 ,558.1702
Set Internal Change=Bald Eagle      ,Loc Hav         ,34098.93, 12 , 3 ,557.9266
Set Internal Change=Bald Eagle      ,Loc Hav         ,33498.68, 12 , 3 ,557.7487
Set Internal Change=Bald Eagle      ,Loc Hav         ,32195.47, 12 , 3 ,556.8521
Set Internal Change=Bald Eagle      ,Loc Hav         ,30878.12, 12 , 3 ,556.0342
Set Internal Change=Bald Eagle      ,Loc Hav         ,29563.77, 12 , 3 ,555.4447
Set Internal Change=Bald Eagle      ,Loc Hav         ,27226.40, 12 , 3 ,552.6478
Set Internal Change=Bald Eagle      ,Loc Hav         ,25960.70, 12 , 3 ,550.4302
Set Internal Change=Bald Eagle      ,Loc Hav         ,24843.25, 12 , 3 ,549.4069
Set Internal Change=Bald Eagle      ,Loc Hav         ,24417.73, 12 , 3 ,549.1567
Set Internal Change=Bald Eagle      ,Loc Hav         ,23872.06, 12 , 3 ,548.3122
Set Internal Change=Bald Eagle      ,Loc Hav         ,23783.65, 12 , 3 ,548.2918
Set Internal Change=Bald Eagle      ,Loc Hav         ,23384.79, 12 , 3 ,548.0621
Set Internal Change=Bald Eagle      ,Loc Hav         ,22982.97, 12 , 3 ,547.7747
Set Internal Change=Bald Eagle      ,Loc Hav         ,22386.15, 12 , 3 ,547.2418
Set Internal Change=Bald Eagle      ,Loc Hav         ,21283.34, 12 , 3 ,546.7098
Set Internal Change=Bald Eagle      ,Loc Hav         ,21199.93, 12 , 3 ,546.6984
Set Internal Change=Bald Eagle      ,Loc Hav         ,20127.30, 12 , 3 ,546.2902
Set Internal Change=Bald Eagle      ,Loc Hav         ,19036.24, 12 , 3 ,544.901
Set Internal Change=Bald Eagle      ,Loc Hav         ,18200.10, 12 , 3 ,544.1277
Set Internal Change=Bald Eagle      ,Loc Hav         ,17549.23, 12 , 3 ,543.9811
Set Internal Change=Bald Eagle      ,Loc Hav         ,16787.45, 12 , 3 ,543.7985
Set Internal Change=Bald Eagle      ,Loc Hav         ,15407.88, 12 , 3 ,543.2577
Set Internal Change=Bald Eagle      ,Loc Hav         ,14814.34, 12 , 3 ,542.8098
Set Internal Change=Bald Eagle      ,Loc Hav         ,13326.74, 12 , 3 ,542.1627
Set Internal Change=Bald Eagle      ,Loc Hav         ,12035.22, 12 , 3 ,541.803
Set Internal Change=Bald Eagle      ,Loc Hav         ,11865.80, 12 , 3 ,541.7607
Set Internal Change=Bald Eagle      ,Loc Hav         ,11116.44, 12 , 3 ,541.3184
Set Internal Change=Bald Eagle      ,Loc Hav         ,10995.73, 12 , 3 ,541.2357
Set Internal Change=Bald Eagle      ,Loc Hav         ,10221.14, 12 , 3 ,540.5554
Set Internal Change=Bald Eagle      ,Loc Hav         ,9258.941, 12 , 3 ,539.9957
Set Internal Change=Bald Eagle      ,Loc Hav         ,8541.462, 12 , 3 ,539.8173
Set Internal Change=Bald Eagle      ,Loc Hav         ,7936.130, 12 , 3 ,539.6278
Set Internal Change=Bald Eagle      ,Loc Hav         ,6940.066, 12 , 3 ,539.1938
Set Internal Change=Bald Eagle      ,Loc Hav         ,6267.489, 12 , 3 ,538.9152
Set Internal Change=Bald Eagle      ,Loc Hav         ,5523.234, 12 , 3 ,538.6766
Set Internal Change=Bald Eagle      ,Loc Hav         ,4293.710, 12 , 3 ,538.1945
Set Internal Change=Bald Eagle      ,Loc Hav         ,3047.378, 12 , 3 ,537.5864
Set Internal Change=Bald Eagle      ,Loc Hav         ,2731.142, 12 , 3 ,537.3109
Set Internal Change=Bald Eagle      ,Loc Hav         ,2501.017, 12 , 3 ,537.265
Set Internal Change=Bald Eagle      ,Loc Hav         ,2371.827, 12 , 3 ,537.2292
Set Internal Change=Bald Eagle      ,Loc Hav         ,1692.633, 12 , 3 ,537.144
Set Internal Change=Bald Eagle      ,Loc Hav         ,1212.855, 12 , 3 ,537.0884
Set Internal Change=Bald Eagle      ,Loc Hav         ,659.942 , 12 , 3 ,536.9836
Set Internal Change=Bald Eagle      ,Loc Hav         ,138154.4, 13 , 3 ,669.3149
Set Internal Change=Bald Eagle      ,Loc Hav         ,137690.8, 13 , 3 ,669.0085
Set Internal Change=Bald Eagle      ,Loc Hav         ,137327.0, 13 , 3 ,668.5663
Set Internal Change=Bald Eagle      ,Loc Hav         ,136564.9, 13 , 3 ,665.5647
Set Internal Change=Bald Eagle      ,Loc Hav         ,136202.3, 13 , 3 ,665.02
Set Internal Change=Bald Eagle      ,Loc Hav         ,135591.4, 13 , 3 ,663.5705
Set Internal Change=Bald Eagle      ,Loc Hav         ,135068.7, 13 , 3 ,662.93
Set Internal Change=Bald Eagle      ,Loc Hav         ,134487.2, 13 , 3 ,661.8602
Set Internal Change=Bald Eagle      ,Loc Hav         ,133881.0, 13 , 3 ,661.1099
Set Internal Change=Bald Eagle      ,Loc Hav         ,133446.1, 13 , 3 ,660.5567
Set Internal Change=Bald Eagle      ,Loc Hav         ,132973.6, 13 , 3 ,659.9783
Set Internal Change=Bald Eagle      ,Loc Hav         ,132363.8, 13 , 3 ,658.6298
Set Internal Change=Bald Eagle      ,Loc Hav         ,131699.7, 13 , 3 ,656.5892
Set Internal Change=Bald Eagle      ,Loc Hav         ,130997.6, 13 , 3 ,654.5978
Set Internal Change=Bald Eagle      ,Loc Hav         ,130339.2, 13 , 3 ,653.1038
Set Internal Change=Bald Eagle      ,Loc Hav         ,129627.5, 13 , 3 ,651.5521
Set Internal Change=Bald Eagle      ,Loc Hav         ,128760.7, 13 , 3 ,649.9317
Set Internal Change=Bald Eagle      ,Loc Hav         ,128280.7, 13 , 3 ,649.3381
Set Internal Change=Bald Eagle      ,Loc Hav         ,127410.9, 13 , 3 ,648.6184
Set Internal Change=Bald Eagle      ,Loc Hav         ,126741.0, 13 , 3 ,647.8919
Set Internal Change=Bald Eagle      ,Loc Hav         ,126454.1, 13 , 3 ,647.2517
Set Internal Change=Bald Eagle      ,Loc Hav         ,126062.6, 13 , 3 ,646.5116
Set Internal Change=Bald Eagle      ,Loc Hav         ,125704.7, 13 , 3 ,645.9281
Set Internal Change=Bald Eagle      ,Loc Hav         ,125091.9, 13 , 3 ,644.9919
Set Internal Change=Bald Eagle      ,Loc Hav         ,124615.5, 13 , 3 ,644.517
Set Internal Change=Bald Eagle      ,Loc Hav         ,124025.0, 13 , 3 ,643.2214
Set Internal Change=Bald Eagle      ,Loc Hav         ,123503.5, 13 , 3 ,642.2166
Set Internal Change=Bald Eagle      ,Loc Hav         ,123123.6, 13 , 3 ,641.6467
Set Internal Change=Bald Eagle      ,Loc Hav         ,122703.3, 13 , 3 ,641.1258
Set Internal Change=Bald Eagle      ,Loc Hav         ,122190.8, 13 , 3 ,640.4401
Set Internal Change=Bald Eagle      ,Loc Hav         ,121754.0, 13 , 3 ,639.9362
Set Internal Change=Bald Eagle      ,Loc Hav         ,121394.1, 13 , 3 ,639.5977
Set Internal Change=Bald Eagle      ,Loc Hav         ,120862.6, 13 , 3 ,639.0339
Set Internal Change=Bald Eagle      ,Loc Hav         ,120421.4, 13 , 3 ,638.2495
Set Internal Change=Bald Eagle      ,Loc Hav         ,119954.9, 13 , 3 ,637.5153
Set Internal Change=Bald Eagle      ,Loc Hav         ,119473.8, 13 , 3 ,636.5579
Set Internal Change=Bald Eagle      ,Loc Hav         ,118901.0, 13 , 3 ,635.2017
Set Internal Change=Bald Eagle      ,Loc Hav         ,118300.5, 13 , 3 ,634.2134
Set Internal Change=Bald Eagle      ,Loc Hav         ,117753.9, 13 , 3 ,633.5142
Set Internal Change=Bald Eagle      ,Loc Hav         ,117180.8, 13 , 3 ,632.5839
Set Internal Change=Bald Eagle      ,Loc Hav         ,116401.3, 13 , 3 ,631.7517
Set Internal Change=Bald Eagle      ,Loc Hav         ,115584.2, 13 , 3 ,631.0632
Set Internal Change=Bald Eagle      ,Loc Hav         ,114899.8, 13 , 3 ,630.3259
Set Internal Change=Bald Eagle      ,Loc Hav         ,113985.6, 13 , 3 ,629.4238
Set Internal Change=Bald Eagle      ,Loc Hav         ,112856.9, 13 , 3 ,628.5781
Set Internal Change=Bald Eagle      ,Loc Hav         ,111971.0, 13 , 3 ,627.9738
Set Internal Change=Bald Eagle      ,Loc Hav         ,110657.4, 13 , 3 ,627.2471
Set Internal Change=Bald Eagle      ,Loc Hav         ,109659.9, 13 , 3 ,626.7247
Set Internal Change=Bald Eagle      ,Loc Hav         ,108600.1, 13 , 3 ,626.2584
Set Internal Change=Bald Eagle      ,Loc Hav         ,107333.6, 13 , 3 ,625.7496
Set Internal Change=Bald Eagle      ,Loc Hav         ,106466.0, 13 , 3 ,625.4896
Set Internal Change=Bald Eagle      ,Loc Hav         ,105178.6, 13 , 3 ,625.2853
Set Internal Change=Bald Eagle      ,Loc Hav         ,104647.2, 13 , 3 ,625.1604
Set Internal Change=Bald Eagle      ,Loc Hav         ,104195.0, 13 , 3 ,625.0846
Set Internal Change=Bald Eagle      ,Loc Hav         ,103854.0, 13 , 3 ,625.0413
Set Internal Change=Bald Eagle      ,Loc Hav         ,103369.7, 13 , 3 ,624.9494
Set Internal Change=Bald Eagle      ,Loc Hav         ,103122.3, 13 , 3 ,624.5997
Set Internal Change=Bald Eagle      ,Loc Hav         ,101440.3, 13 , 3 ,624.3857
Set Internal Change=Bald Eagle      ,Loc Hav         ,100657.3, 13 , 3 ,624.3395
Set Internal Change=Bald Eagle      ,Loc Hav         ,99452.75, 13 , 3 ,624.3073
Set Internal Change=Bald Eagle      ,Loc Hav         ,98206.87, 13 , 3 ,624.2883
Set Internal Change=Bald Eagle      ,Loc Hav         ,97607.35, 13 , 3 ,624.2414
Set Internal Change=Bald Eagle      ,Loc Hav         ,96370.43, 13 , 3 ,624.2142
Set Internal Change=Bald Eagle      ,Loc Hav         ,94560.01, 13 , 3 ,624.2028
Set Internal Change=Bald Eagle      ,Loc Hav         ,93391.71, 13 , 3 ,624.1973
Set Internal Change=Bald Eagle      ,Loc Hav         ,92011.85, 13 , 3 ,624.1913
Set Internal Change=Bald Eagle      ,Loc Hav         ,91030.01, 13 , 3 ,624.1873
Set Internal Change=Bald Eagle      ,Loc Hav         ,90096.99, 13 , 3 ,624.1866
Set Internal Change=Bald Eagle      ,Loc Hav         ,89060.69, 13 , 3 ,624.1855
Set Internal Change=Bald Eagle      ,Loc Hav         ,87861.14, 13 , 3 ,624.1851
Set Internal Change=Bald Eagle      ,Loc Hav         ,86942.04, 13 , 3 ,624.185
Set Internal Change=Bald Eagle      ,Loc Hav         ,85569.53, 13 , 3 ,624.1851
Set Internal Change=Bald Eagle      ,Loc Hav         ,84724.08, 13 , 3 ,624.1849
Set Internal Change=Bald Eagle      ,Loc Hav         ,83563.41, 13 , 3 ,624.1849
Set Internal Change=Bald Eagle      ,Loc Hav         ,82607.89, 13 , 3 ,624.1849
Set Internal Change=Bald Eagle      ,Loc Hav         ,81849.41, 13 , 3 ,624.1838
Set Internal Change=Bald Eagle      ,Loc Hav         ,81084.18, 13 , 3 ,592.013
Set Internal Change=Bald Eagle      ,Loc Hav         ,80500.50, 13 , 3 ,590.3121
Set Internal Change=Bald Eagle      ,Loc Hav         ,79684.28, 13 , 3 ,589.4157
Set Internal Change=Bald Eagle      ,Loc Hav         ,78627.87, 13 , 3 ,588.834
Set Internal Change=Bald Eagle      ,Loc Hav         ,76643.40, 13 , 3 ,587.3947
Set Internal Change=Bald Eagle      ,Loc Hav         ,76002.96, 13 , 3 ,586.7551
Set Internal Change=Bald Eagle      ,Loc Hav         ,75917.82, 13 , 3 ,586.6292
Set Internal Change=Bald Eagle      ,Loc Hav         ,75616.14, 13 , 3 ,586.1234
Set Internal Change=Bald Eagle      ,Loc Hav         ,74650.60, 13 , 3 ,585.1411
Set Internal Change=Bald Eagle      ,Loc Hav         ,74207.96, 13 , 3 ,584.7634
Set Internal Change=Bald Eagle      ,Loc Hav         ,73504.24, 13 , 3 ,584.1768
Set Internal Change=Bald Eagle      ,Loc Hav         ,72303.68, 13 , 3 ,583.4107
Set Internal Change=Bald Eagle      ,Loc Hav         ,71400.81, 13 , 3 ,582.6246
Set Internal Change=Bald Eagle      ,Loc Hav         ,70651.52, 13 , 3 ,581.9637
Set Internal Change=Bald Eagle      ,Loc Hav         ,69567.33, 13 , 3 ,581.0935
Set Internal Change=Bald Eagle      ,Loc Hav         ,68604.09, 13 , 3 ,580.494
Set Internal Change=Bald Eagle      ,Loc Hav         ,67326.78, 13 , 3 ,579.7609
Set Internal Change=Bald Eagle      ,Loc Hav         ,66070.17, 13 , 3 ,578.6635
Set Internal Change=Bald Eagle      ,Loc Hav         ,64908.02, 13 , 3 ,577.3416
Set Internal Change=Bald Eagle      ,Loc Hav         ,63812.99, 13 , 3 ,575.9893
Set Internal Change=Bald Eagle      ,Loc Hav         ,62746.41, 13 , 3 ,574.9197
Set Internal Change=Bald Eagle      ,Loc Hav         ,61896.89, 13 , 3 ,574.1415
Set Internal Change=Bald Eagle      ,Loc Hav         ,60901.09, 13 , 3 ,573.1343
Set Internal Change=Bald Eagle      ,Loc Hav         ,59795.28, 13 , 3 ,572.1704
Set Internal Change=Bald Eagle      ,Loc Hav         ,58836.23, 13 , 3 ,571.5411
Set Internal Change=Bald Eagle      ,Loc Hav         ,58708.54, 13 , 3 ,571.4622
Set Internal Change=Bald Eagle      ,Loc Hav         ,58091.91, 13 , 3 ,571.1265
Set Internal Change=Bald Eagle      ,Loc Hav         ,57700.27, 13 , 3 ,570.8156
Set Internal Change=Bald Eagle      ,Loc Hav         ,57250.60, 13 , 3 ,570.5675
Set Internal Change=Bald Eagle      ,Loc Hav         ,56775.92, 13 , 3 ,570.165
Set Internal Change=Bald Eagle      ,Loc Hav         ,56243.79, 13 , 3 ,569.8593
Set Internal Change=Bald Eagle      ,Loc Hav         ,55700.55, 13 , 3 ,569.4948
Set Internal Change=Bald Eagle      ,Loc Hav         ,54696.51, 13 , 3 ,568.8704
Set Internal Change=Bald Eagle      ,Loc Hav         ,53922.53, 13 , 3 ,568.2349
Set Internal Change=Bald Eagle      ,Loc Hav         ,52879.19, 13 , 3 ,567.5159
Set Internal Change=Bald Eagle      ,Loc Hav         ,51784.74, 13 , 3 ,566.7895
Set Internal Change=Bald Eagle      ,Loc Hav         ,50720.68, 13 , 3 ,566.2993
Set Internal Change=Bald Eagle      ,Loc Hav         ,49715.77, 13 , 3 ,566.0864
Set Internal Change=Bald Eagle      ,Loc Hav         ,48965.94, 13 , 3 ,565.8698
Set Internal Change=Bald Eagle      ,Loc Hav         ,48110.09, 13 , 3 ,564.8001
Set Internal Change=Bald Eagle      ,Loc Hav         ,47453.14, 13 , 3 ,564.0475
Set Internal Change=Bald Eagle      ,Loc Hav         ,46722.59, 13 , 3 ,563.428
Set Internal Change=Bald Eagle      ,Loc Hav         ,46310.48, 13 , 3 ,563.1925
Set Internal Change=Bald Eagle      ,Loc Hav         ,45805.37, 13 , 3 ,562.9372
Set Internal Change=Bald Eagle      ,Loc Hav         ,45233.89, 13 , 3 ,562.6544
Set Internal Change=Bald Eagle      ,Loc Hav         ,44529.29, 13 , 3 ,562.2527
Set Internal Change=Bald Eagle      ,Loc Hav         ,43919.30, 13 , 3 ,562.0001
Set Internal Change=Bald Eagle      ,Loc Hav         ,42895.87, 13 , 3 ,561.4492
Set Internal Change=Bald Eagle      ,Loc Hav         ,41806.43, 13 , 3 ,560.8549
Set Internal Change=Bald Eagle      ,Loc Hav         ,40526.85, 13 , 3 ,560.4785
Set Internal Change=Bald Eagle      ,Loc Hav         ,39499.37, 13 , 3 ,560.2871
Set Internal Change=Bald Eagle      ,Loc Hav         ,38446.87, 13 , 3 ,559.9313
Set Internal Change=Bald Eagle      ,Loc Hav         ,37962.54, 13 , 3 ,559.706
Set Internal Change=Bald Eagle      ,Loc Hav         ,37385.23, 13 , 3 ,559.488
Set Internal Change=Bald Eagle      ,Loc Hav         ,36769.88, 13 , 3 ,559.3412
Set Internal Change=Bald Eagle      ,Loc Hav         ,36663.76, 13 , 3 ,559.2625
Set Internal Change=Bald Eagle      ,Loc Hav         ,36339.56, 13 , 3 ,559.0733
Set Internal Change=Bald Eagle      ,Loc Hav         ,35648.50, 13 , 3 ,558.7285
Set Internal Change=Bald Eagle      ,Loc Hav         ,35072.37, 13 , 3 ,558.5471
Set Internal Change=Bald Eagle      ,Loc Hav         ,34098.93, 13 , 3 ,558.2903
Set Internal Change=Bald Eagle      ,Loc Hav         ,33498.68, 13 , 3 ,558.0974
Set Internal Change=Bald Eagle      ,Loc Hav         ,32195.47, 13 , 3 ,557.1565
Set Internal Change=Bald Eagle      ,Loc Hav         ,30878.12, 13 , 3 ,556.3171
Set Internal Change=Bald Eagle      ,Loc Hav         ,29563.77, 13 , 3 ,555.758
Set Internal Change=Bald Eagle      ,Loc Hav         ,27226.40, 13 , 3 ,552.9661
Set Internal Change=Bald Eagle      ,Loc Hav         ,25960.70, 13 , 3 ,550.7386
Set Internal Change=Bald Eagle      ,Loc Hav         ,24843.25, 13 , 3 ,549.7152
Set Internal Change=Bald Eagle      ,Loc Hav         ,24417.73, 13 , 3 ,549.467
Set Internal Change=Bald Eagle      ,Loc Hav         ,23872.06, 13 , 3 ,548.5975
Set Internal Change=Bald Eagle      ,Loc Hav         ,23783.65, 13 , 3 ,548.5746
Set Internal Change=Bald Eagle      ,Loc Hav         ,23384.79, 13 , 3 ,548.3595
Set Internal Change=Bald Eagle      ,Loc Hav         ,22982.97, 13 , 3 ,548.103
Set Internal Change=Bald Eagle      ,Loc Hav         ,22386.15, 13 , 3 ,547.602
Set Internal Change=Bald Eagle      ,Loc Hav         ,21283.34, 13 , 3 ,547.0703
Set Internal Change=Bald Eagle      ,Loc Hav         ,21199.93, 13 , 3 ,547.0544
Set Internal Change=Bald Eagle      ,Loc Hav         ,20127.30, 13 , 3 ,546.6124
Set Internal Change=Bald Eagle      ,Loc Hav         ,19036.24, 13 , 3 ,545.2402
Set Internal Change=Bald Eagle      ,Loc Hav         ,18200.10, 13 , 3 ,544.5065
Set Internal Change=Bald Eagle      ,Loc Hav         ,17549.23, 13 , 3 ,544.3599
Set Internal Change=Bald Eagle      ,Loc Hav         ,16787.45, 13 , 3 ,544.1693
Set Internal Change=Bald Eagle      ,Loc Hav         ,15407.88, 13 , 3 ,543.6058
Set Internal Change=Bald Eagle      ,Loc Hav         ,14814.34, 13 , 3 ,543.1554
Set Internal Change=Bald Eagle      ,Loc Hav         ,13326.74, 13 , 3 ,542.4977
Set Internal Change=Bald Eagle      ,Loc Hav         ,12035.22, 13 , 3 ,542.1271
Set Internal Change=Bald Eagle      ,Loc Hav         ,11865.80, 13 , 3 ,542.0839
Set Internal Change=Bald Eagle      ,Loc Hav         ,11116.44, 13 , 3 ,541.6553
Set Internal Change=Bald Eagle      ,Loc Hav         ,10995.73, 13 , 3 ,541.5796
Set Internal Change=Bald Eagle      ,Loc Hav         ,10221.14, 13 , 3 ,540.9727
Set Internal Change=Bald Eagle      ,Loc Hav         ,9258.941, 13 , 3 ,540.4757
Set Internal Change=Bald Eagle      ,Loc Hav         ,8541.462, 13 , 3 ,540.311
Set Internal Change=Bald Eagle      ,Loc Hav         ,7936.130, 13 , 3 ,540.132
Set Internal Change=Bald Eagle      ,Loc Hav         ,6940.066, 13 , 3 ,539.7324
Set Internal Change=Bald Eagle      ,Loc Hav         ,6267.489, 13 , 3 ,539.481
Set Internal Change=Bald Eagle      ,Loc Hav         ,5523.234, 13 , 3 ,539.2654
Set Internal Change=Bald Eagle      ,Loc Hav         ,4293.710, 13 , 3 ,538.847
Set Internal Change=Bald Eagle      ,Loc Hav         ,3047.378, 13 , 3 ,538.3587
Set Internal Change=Bald Eagle      ,Loc Hav         ,2731.142, 13 , 3 ,538.1589
Set Internal Change=Bald Eagle      ,Loc Hav         ,2501.017, 13 , 3 ,538.1321
Set Internal Change=Bald Eagle      ,Loc Hav         ,2371.827, 13 , 3 ,538.1056
Set Internal Change=Bald Eagle      ,Loc Hav         ,1692.633, 13 , 3 ,538.0379
Set Internal Change=Bald Eagle      ,Loc Hav         ,1212.855, 13 , 3 ,537.9921
Set Internal Change=Bald Eagle      ,Loc Hav         ,659.942 , 13 , 3 ,537.9139
Set Internal Change=Bald Eagle      ,Loc Hav         ,138154.4, 14 , 3 ,669.7761
Set Internal Change=Bald Eagle      ,Loc Hav         ,137690.8, 14 , 3 ,669.4967
Set Internal Change=Bald Eagle      ,Loc Hav         ,137327.0, 14 , 3 ,669.0544
Set Internal Change=Bald Eagle      ,Loc Hav         ,136564.9, 14 , 3 ,665.983
Set Internal Change=Bald Eagle      ,Loc Hav         ,136202.3, 14 , 3 ,665.454
Set Internal Change=Bald Eagle      ,Loc Hav         ,135591.4, 14 , 3 ,663.9647
Set Internal Change=Bald Eagle      ,Loc Hav         ,135068.7, 14 , 3 ,663.3358
Set Internal Change=Bald Eagle      ,Loc Hav         ,134487.2, 14 , 3 ,662.2648
Set Internal Change=Bald Eagle      ,Loc Hav         ,133881.0, 14 , 3 ,661.5169
Set Internal Change=Bald Eagle      ,Loc Hav         ,133446.1, 14 , 3 ,660.9481
Set Internal Change=Bald Eagle      ,Loc Hav         ,132973.6, 14 , 3 ,660.3612
Set Internal Change=Bald Eagle      ,Loc Hav         ,132363.8, 14 , 3 ,658.9785
Set Internal Change=Bald Eagle      ,Loc Hav         ,131699.7, 14 , 3 ,656.9065
Set Internal Change=Bald Eagle      ,Loc Hav         ,130997.6, 14 , 3 ,654.9121
Set Internal Change=Bald Eagle      ,Loc Hav         ,130339.2, 14 , 3 ,653.4028
Set Internal Change=Bald Eagle      ,Loc Hav         ,129627.5, 14 , 3 ,651.8338
Set Internal Change=Bald Eagle      ,Loc Hav         ,128760.7, 14 , 3 ,650.285
Set Internal Change=Bald Eagle      ,Loc Hav         ,128280.7, 14 , 3 ,649.7352
Set Internal Change=Bald Eagle      ,Loc Hav         ,127410.9, 14 , 3 ,649.0372
Set Internal Change=Bald Eagle      ,Loc Hav         ,126741.0, 14 , 3 ,648.3219
Set Internal Change=Bald Eagle      ,Loc Hav         ,126454.1, 14 , 3 ,647.6671
Set Internal Change=Bald Eagle      ,Loc Hav         ,126062.6, 14 , 3 ,646.9216
Set Internal Change=Bald Eagle      ,Loc Hav         ,125704.7, 14 , 3 ,646.3364
Set Internal Change=Bald Eagle      ,Loc Hav         ,125091.9, 14 , 3 ,645.3863
Set Internal Change=Bald Eagle      ,Loc Hav         ,124615.5, 14 , 3 ,644.9061
Set Internal Change=Bald Eagle      ,Loc Hav         ,124025.0, 14 , 3 ,643.6182
Set Internal Change=Bald Eagle      ,Loc Hav         ,123503.5, 14 , 3 ,642.6309
Set Internal Change=Bald Eagle      ,Loc Hav         ,123123.6, 14 , 3 ,642.0681
Set Internal Change=Bald Eagle      ,Loc Hav         ,122703.3, 14 , 3 ,641.5527
Set Internal Change=Bald Eagle      ,Loc Hav         ,122190.8, 14 , 3 ,640.8785
Set Internal Change=Bald Eagle      ,Loc Hav         ,121754.0, 14 , 3 ,640.3767
Set Internal Change=Bald Eagle      ,Loc Hav         ,121394.1, 14 , 3 ,640.032
Set Internal Change=Bald Eagle      ,Loc Hav         ,120862.6, 14 , 3 ,639.4607
Set Internal Change=Bald Eagle      ,Loc Hav         ,120421.4, 14 , 3 ,638.6725
Set Internal Change=Bald Eagle      ,Loc Hav         ,119954.9, 14 , 3 ,637.9288
Set Internal Change=Bald Eagle      ,Loc Hav         ,119473.8, 14 , 3 ,636.9486
Set Internal Change=Bald Eagle      ,Loc Hav         ,118901.0, 14 , 3 ,635.5613
Set Internal Change=Bald Eagle      ,Loc Hav         ,118300.5, 14 , 3 ,634.5427
Set Internal Change=Bald Eagle      ,Loc Hav         ,117753.9, 14 , 3 ,633.853
Set Internal Change=Bald Eagle      ,Loc Hav         ,117180.8, 14 , 3 ,632.9785
Set Internal Change=Bald Eagle      ,Loc Hav         ,116401.3, 14 , 3 ,632.2027
Set Internal Change=Bald Eagle      ,Loc Hav         ,115584.2, 14 , 3 ,631.5775
Set Internal Change=Bald Eagle      ,Loc Hav         ,114899.8, 14 , 3 ,630.9642
Set Internal Change=Bald Eagle      ,Loc Hav         ,113985.6, 14 , 3 ,630.2431
Set Internal Change=Bald Eagle      ,Loc Hav         ,112856.9, 14 , 3 ,629.5992
Set Internal Change=Bald Eagle      ,Loc Hav         ,111971.0, 14 , 3 ,629.2039
Set Internal Change=Bald Eagle      ,Loc Hav         ,110657.4, 14 , 3 ,628.7462
Set Internal Change=Bald Eagle      ,Loc Hav         ,109659.9, 14 , 3 ,628.434
Set Internal Change=Bald Eagle      ,Loc Hav         ,108600.1, 14 , 3 ,628.1616
Set Internal Change=Bald Eagle      ,Loc Hav         ,107333.6, 14 , 3 ,627.9023
Set Internal Change=Bald Eagle      ,Loc Hav         ,106466.0, 14 , 3 ,627.7809
Set Internal Change=Bald Eagle      ,Loc Hav         ,105178.6, 14 , 3 ,627.6797
Set Internal Change=Bald Eagle      ,Loc Hav         ,104647.2, 14 , 3 ,627.6152
Set Internal Change=Bald Eagle      ,Loc Hav         ,104195.0, 14 , 3 ,627.5802
Set Internal Change=Bald Eagle      ,Loc Hav         ,103854.0, 14 , 3 ,627.558
Set Internal Change=Bald Eagle      ,Loc Hav         ,103369.7, 14 , 3 ,627.5058
Set Internal Change=Bald Eagle      ,Loc Hav         ,103122.3, 14 , 3 ,627.2863
Set Internal Change=Bald Eagle      ,Loc Hav         ,101440.3, 14 , 3 ,627.1943
Set Internal Change=Bald Eagle      ,Loc Hav         ,100657.3, 14 , 3 ,627.1725
Set Internal Change=Bald Eagle      ,Loc Hav         ,99452.75, 14 , 3 ,627.1567
Set Internal Change=Bald Eagle      ,Loc Hav         ,98206.87, 14 , 3 ,627.1481
Set Internal Change=Bald Eagle      ,Loc Hav         ,97607.35, 14 , 3 ,627.1222
Set Internal Change=Bald Eagle      ,Loc Hav         ,96370.43, 14 , 3 ,627.1096
Set Internal Change=Bald Eagle      ,Loc Hav         ,94560.01, 14 , 3 ,627.1031
Set Internal Change=Bald Eagle      ,Loc Hav         ,93391.71, 14 , 3 ,627.0991
Set Internal Change=Bald Eagle      ,Loc Hav         ,92011.85, 14 , 3 ,627.0948
Set Internal Change=Bald Eagle      ,Loc Hav         ,91030.01, 14 , 3 ,627.0919
Set Internal Change=Bald Eagle      ,Loc Hav         ,90096.99, 14 , 3 ,627.0916
Set Internal Change=Bald Eagle      ,Loc Hav         ,89060.69, 14 , 3 ,627.0908
Set Internal Change=Bald Eagle      ,Loc Hav         ,87861.14, 14 , 3 ,627.0905
Set Internal Change=Bald Eagle      ,Loc Hav         ,86942.04, 14 , 3 ,627.0904
Set Internal Change=Bald Eagle      ,Loc Hav         ,85569.53, 14 , 3 ,627.0904
Set Internal Change=Bald Eagle      ,Loc Hav         ,84724.08, 14 , 3 ,627.0903
Set Internal Change=Bald Eagle      ,Loc Hav         ,83563.41, 14 , 3 ,627.0902
Set Internal Change=Bald Eagle      ,Loc Hav         ,82607.89, 14 , 3 ,627.0901
Set Internal Change=Bald Eagle      ,Loc Hav         ,81849.41, 14 , 3 ,627.0894
Set Internal Change=Bald Eagle      ,Loc Hav         ,81084.18, 14 , 3 ,592.3334
Set Internal Change=Bald Eagle      ,Loc Hav         ,80500.50, 14 , 3 ,590.6038
Set Internal Change=Bald Eagle      ,Loc Hav         ,79684.28, 14 , 3 ,589.6818
Set Internal Change=Bald Eagle      ,Loc Hav         ,78627.87, 14 , 3 ,589.0752
Set Internal Change=Bald Eagle      ,Loc Hav         ,76643.40, 14 , 3 ,587.6329
Set Internal Change=Bald Eagle      ,Loc Hav         ,76002.96, 14 , 3 ,586.9669
Set Internal Change=Bald Eagle      ,Loc Hav         ,75917.82, 14 , 3 ,586.8326
Set Internal Change=Bald Eagle      ,Loc Hav         ,75616.14, 14 , 3 ,586.3104
Set Internal Change=Bald Eagle      ,Loc Hav         ,74650.60, 14 , 3 ,585.2822
Set Internal Change=Bald Eagle      ,Loc Hav         ,74207.96, 14 , 3 ,584.9021
Set Internal Change=Bald Eagle      ,Loc Hav         ,73504.24, 14 , 3 ,584.33
Set Internal Change=Bald Eagle      ,Loc Hav         ,72303.68, 14 , 3 ,583.5947
Set Internal Change=Bald Eagle      ,Loc Hav         ,71400.81, 14 , 3 ,582.8793
Set Internal Change=Bald Eagle      ,Loc Hav         ,70651.52, 14 , 3 ,582.2559
Set Internal Change=Bald Eagle      ,Loc Hav         ,69567.33, 14 , 3 ,581.3931
Set Internal Change=Bald Eagle      ,Loc Hav         ,68604.09, 14 , 3 ,580.7798
Set Internal Change=Bald Eagle      ,Loc Hav         ,67326.78, 14 , 3 ,580.0589
Set Internal Change=Bald Eagle      ,Loc Hav         ,66070.17, 14 , 3 ,578.9562
Set Internal Change=Bald Eagle      ,Loc Hav         ,64908.02, 14 , 3 ,577.6237
Set Internal Change=Bald Eagle      ,Loc Hav         ,63812.99, 14 , 3 ,576.2435
Set Internal Change=Bald Eagle      ,Loc Hav         ,62746.41, 14 , 3 ,575.1914
Set Internal Change=Bald Eagle      ,Loc Hav         ,61896.89, 14 , 3 ,574.4416
Set Internal Change=Bald Eagle      ,Loc Hav         ,60901.09, 14 , 3 ,573.4585
Set Internal Change=Bald Eagle      ,Loc Hav         ,59795.28, 14 , 3 ,572.4998
Set Internal Change=Bald Eagle      ,Loc Hav         ,58836.23, 14 , 3 ,571.8604
Set Internal Change=Bald Eagle      ,Loc Hav         ,58708.54, 14 , 3 ,571.7788
Set Internal Change=Bald Eagle      ,Loc Hav         ,58091.91, 14 , 3 ,571.4521
Set Internal Change=Bald Eagle      ,Loc Hav         ,57700.27, 14 , 3 ,571.1508
Set Internal Change=Bald Eagle      ,Loc Hav         ,57250.60, 14 , 3 ,570.8964
Set Internal Change=Bald Eagle      ,Loc Hav         ,56775.92, 14 , 3 ,570.4767
Set Internal Change=Bald Eagle      ,Loc Hav         ,56243.79, 14 , 3 ,570.1658
Set Internal Change=Bald Eagle      ,Loc Hav         ,55700.55, 14 , 3 ,569.7853
Set Internal Change=Bald Eagle      ,Loc Hav         ,54696.51, 14 , 3 ,569.1248
Set Internal Change=Bald Eagle      ,Loc Hav         ,53922.53, 14 , 3 ,568.5103
Set Internal Change=Bald Eagle      ,Loc Hav         ,52879.19, 14 , 3 ,567.798
Set Internal Change=Bald Eagle      ,Loc Hav         ,51784.74, 14 , 3 ,567.1044
Set Internal Change=Bald Eagle      ,Loc Hav         ,50720.68, 14 , 3 ,566.6089
Set Internal Change=Bald Eagle      ,Loc Hav         ,49715.77, 14 , 3 ,566.4017
Set Internal Change=Bald Eagle      ,Loc Hav         ,48965.94, 14 , 3 ,566.2009
Set Internal Change=Bald Eagle      ,Loc Hav         ,48110.09, 14 , 3 ,565.0943
Set Internal Change=Bald Eagle      ,Loc Hav         ,47453.14, 14 , 3 ,564.3078
Set Internal Change=Bald Eagle      ,Loc Hav         ,46722.59, 14 , 3 ,563.6691
Set Internal Change=Bald Eagle      ,Loc Hav         ,46310.48, 14 , 3 ,563.4378
Set Internal Change=Bald Eagle      ,Loc Hav         ,45805.37, 14 , 3 ,563.1738
Set Internal Change=Bald Eagle      ,Loc Hav         ,45233.89, 14 , 3 ,562.875
Set Internal Change=Bald Eagle      ,Loc Hav         ,44529.29, 14 , 3 ,562.4572
Set Internal Change=Bald Eagle      ,Loc Hav         ,43919.30, 14 , 3 ,562.1916
Set Internal Change=Bald Eagle      ,Loc Hav         ,42895.87, 14 , 3 ,561.6816
Set Internal Change=Bald Eagle      ,Loc Hav         ,41806.43, 14 , 3 ,561.1468
Set Internal Change=Bald Eagle      ,Loc Hav         ,40526.85, 14 , 3 ,560.7905
Set Internal Change=Bald Eagle      ,Loc Hav         ,39499.37, 14 , 3 ,560.6031
Set Internal Change=Bald Eagle      ,Loc Hav         ,38446.87, 14 , 3 ,560.2676
Set Internal Change=Bald Eagle      ,Loc Hav         ,37962.54, 14 , 3 ,560.0595
Set Internal Change=Bald Eagle      ,Loc Hav         ,37385.23, 14 , 3 ,559.8497
Set Internal Change=Bald Eagle      ,Loc Hav         ,36769.88, 14 , 3 ,559.6895
Set Internal Change=Bald Eagle      ,Loc Hav         ,36663.76, 14 , 3 ,559.5992
Set Internal Change=Bald Eagle      ,Loc Hav         ,36339.56, 14 , 3 ,559.4197
Set Internal Change=Bald Eagle      ,Loc Hav         ,35648.50, 14 , 3 ,559.064
Set Internal Change=Bald Eagle      ,Loc Hav         ,35072.37, 14 , 3 ,558.8803
Set Internal Change=Bald Eagle      ,Loc Hav         ,34098.93, 14 , 3 ,558.624
Set Internal Change=Bald Eagle      ,Loc Hav         ,33498.68, 14 , 3 ,558.4299
Set Internal Change=Bald Eagle      ,Loc Hav         ,32195.47, 14 , 3 ,557.4346
Set Internal Change=Bald Eagle      ,Loc Hav         ,30878.12, 14 , 3 ,556.5547
Set Internal Change=Bald Eagle      ,Loc Hav         ,29563.77, 14 , 3 ,555.9911
Set Internal Change=Bald Eagle      ,Loc Hav         ,27226.40, 14 , 3 ,553.2334
Set Internal Change=Bald Eagle      ,Loc Hav         ,25960.70, 14 , 3 ,551.0363
Set Internal Change=Bald Eagle      ,Loc Hav         ,24843.25, 14 , 3 ,550.0225
Set Internal Change=Bald Eagle      ,Loc Hav         ,24417.73, 14 , 3 ,549.778
Set Internal Change=Bald Eagle      ,Loc Hav         ,23872.06, 14 , 3 ,548.9003
Set Internal Change=Bald Eagle      ,Loc Hav         ,23783.65, 14 , 3 ,548.8745
Set Internal Change=Bald Eagle      ,Loc Hav         ,23384.79, 14 , 3 ,548.6761
Set Internal Change=Bald Eagle      ,Loc Hav         ,22982.97, 14 , 3 ,548.4625
Set Internal Change=Bald Eagle      ,Loc Hav         ,22386.15, 14 , 3 ,548.0087
Set Internal Change=Bald Eagle      ,Loc Hav         ,21283.34, 14 , 3 ,547.4854
Set Internal Change=Bald Eagle      ,Loc Hav         ,21199.93, 14 , 3 ,547.4676
Set Internal Change=Bald Eagle      ,Loc Hav         ,20127.30, 14 , 3 ,546.9962
Set Internal Change=Bald Eagle      ,Loc Hav         ,19036.24, 14 , 3 ,545.662
Set Internal Change=Bald Eagle      ,Loc Hav         ,18200.10, 14 , 3 ,544.988
Set Internal Change=Bald Eagle      ,Loc Hav         ,17549.23, 14 , 3 ,544.8491
Set Internal Change=Bald Eagle      ,Loc Hav         ,16787.45, 14 , 3 ,544.6581
Set Internal Change=Bald Eagle      ,Loc Hav         ,15407.88, 14 , 3 ,544.0874
Set Internal Change=Bald Eagle      ,Loc Hav         ,14814.34, 14 , 3 ,543.6158
Set Internal Change=Bald Eagle      ,Loc Hav         ,13326.74, 14 , 3 ,542.965
Set Internal Change=Bald Eagle      ,Loc Hav         ,12035.22, 14 , 3 ,542.5971
Set Internal Change=Bald Eagle      ,Loc Hav         ,11865.80, 14 , 3 ,542.5537
Set Internal Change=Bald Eagle      ,Loc Hav         ,11116.44, 14 , 3 ,542.148
Set Internal Change=Bald Eagle      ,Loc Hav         ,10995.73, 14 , 3 ,542.0807
Set Internal Change=Bald Eagle      ,Loc Hav         ,10221.14, 14 , 3 ,541.5474
Set Internal Change=Bald Eagle      ,Loc Hav         ,9258.941, 14 , 3 ,541.11
Set Internal Change=Bald Eagle      ,Loc Hav         ,8541.462, 14 , 3 ,540.9601
Set Internal Change=Bald Eagle      ,Loc Hav         ,7936.130, 14 , 3 ,540.7986
Set Internal Change=Bald Eagle      ,Loc Hav         ,6940.066, 14 , 3 ,540.444
Set Internal Change=Bald Eagle      ,Loc Hav         ,6267.489, 14 , 3 ,540.2269
Set Internal Change=Bald Eagle      ,Loc Hav         ,5523.234, 14 , 3 ,540.0377
Set Internal Change=Bald Eagle      ,Loc Hav         ,4293.710, 14 , 3 ,539.6875
Set Internal Change=Bald Eagle      ,Loc Hav         ,3047.378, 14 , 3 ,539.3179
Set Internal Change=Bald Eagle      ,Loc Hav         ,2731.142, 14 , 3 ,539.1684
Set Internal Change=Bald Eagle      ,Loc Hav         ,2501.017, 14 , 3 ,539.1563
Set Internal Change=Bald Eagle      ,Loc Hav         ,2371.827, 14 , 3 ,539.1364
Set Internal Change=Bald Eagle      ,Loc Hav         ,1692.633, 14 , 3 ,539.0828
Set Internal Change=Bald Eagle      ,Loc Hav         ,1212.855, 14 , 3 ,539.0447
Set Internal Change=Bald Eagle      ,Loc Hav         ,659.942 , 14 , 3 ,538.9895
Set Internal Change=Bald Eagle      ,Loc Hav         ,138154.4, 15 , 3 ,670.2303
Set Internal Change=Bald Eagle      ,Loc Hav         ,137690.8, 15 , 3 ,669.9765
Set Internal Change=Bald Eagle      ,Loc Hav         ,137327.0, 15 , 3 ,669.5333
Set Internal Change=Bald Eagle      ,Loc Hav         ,136564.9, 15 , 3 ,666.3812
Set Internal Change=Bald Eagle      ,Loc Hav         ,136202.3, 15 , 3 ,665.8616
Set Internal Change=Bald Eagle      ,Loc Hav         ,135591.4, 15 , 3 ,664.3168
Set Internal Change=Bald Eagle      ,Loc Hav         ,135068.7, 15 , 3 ,663.7061
Set Internal Change=Bald Eagle      ,Loc Hav         ,134487.2, 15 , 3 ,662.6501
Set Internal Change=Bald Eagle      ,Loc Hav         ,133881.0, 15 , 3 ,661.9103
Set Internal Change=Bald Eagle      ,Loc Hav         ,133446.1, 15 , 3 ,661.3248
Set Internal Change=Bald Eagle      ,Loc Hav         ,132973.6, 15 , 3 ,660.7278
Set Internal Change=Bald Eagle      ,Loc Hav         ,132363.8, 15 , 3 ,659.3051
Set Internal Change=Bald Eagle      ,Loc Hav         ,131699.7, 15 , 3 ,657.2072
Set Internal Change=Bald Eagle      ,Loc Hav         ,130997.6, 15 , 3 ,655.2158
Set Internal Change=Bald Eagle      ,Loc Hav         ,130339.2, 15 , 3 ,653.6859
Set Internal Change=Bald Eagle      ,Loc Hav         ,129627.5, 15 , 3 ,652.1135
Set Internal Change=Bald Eagle      ,Loc Hav         ,128760.7, 15 , 3 ,650.6373
Set Internal Change=Bald Eagle      ,Loc Hav         ,128280.7, 15 , 3 ,650.1224
Set Internal Change=Bald Eagle      ,Loc Hav         ,127410.9, 15 , 3 ,649.4426
Set Internal Change=Bald Eagle      ,Loc Hav         ,126741.0, 15 , 3 ,648.7327
Set Internal Change=Bald Eagle      ,Loc Hav         ,126454.1, 15 , 3 ,648.0615
Set Internal Change=Bald Eagle      ,Loc Hav         ,126062.6, 15 , 3 ,647.3066
Set Internal Change=Bald Eagle      ,Loc Hav         ,125704.7, 15 , 3 ,646.7211
Set Internal Change=Bald Eagle      ,Loc Hav         ,125091.9, 15 , 3 ,645.7692
Set Internal Change=Bald Eagle      ,Loc Hav         ,124615.5, 15 , 3 ,645.2883
Set Internal Change=Bald Eagle      ,Loc Hav         ,124025.0, 15 , 3 ,644.0054
Set Internal Change=Bald Eagle      ,Loc Hav         ,123503.5, 15 , 3 ,643.0356
Set Internal Change=Bald Eagle      ,Loc Hav         ,123123.6, 15 , 3 ,642.4794
Set Internal Change=Bald Eagle      ,Loc Hav         ,122703.3, 15 , 3 ,641.9678
Set Internal Change=Bald Eagle      ,Loc Hav         ,122190.8, 15 , 3 ,641.3011
Set Internal Change=Bald Eagle      ,Loc Hav         ,121754.0, 15 , 3 ,640.7988
Set Internal Change=Bald Eagle      ,Loc Hav         ,121394.1, 15 , 3 ,640.4504
Set Internal Change=Bald Eagle      ,Loc Hav         ,120862.6, 15 , 3 ,639.8761
Set Internal Change=Bald Eagle      ,Loc Hav         ,120421.4, 15 , 3 ,639.0827
Set Internal Change=Bald Eagle      ,Loc Hav         ,119954.9, 15 , 3 ,638.3283
Set Internal Change=Bald Eagle      ,Loc Hav         ,119473.8, 15 , 3 ,637.3488
Set Internal Change=Bald Eagle      ,Loc Hav         ,118901.0, 15 , 3 ,635.9781
Set Internal Change=Bald Eagle      ,Loc Hav         ,118300.5, 15 , 3 ,634.9689
Set Internal Change=Bald Eagle      ,Loc Hav         ,117753.9, 15 , 3 ,634.3367
Set Internal Change=Bald Eagle      ,Loc Hav         ,117180.8, 15 , 3 ,633.5988
Set Internal Change=Bald Eagle      ,Loc Hav         ,116401.3, 15 , 3 ,632.9847
Set Internal Change=Bald Eagle      ,Loc Hav         ,115584.2, 15 , 3 ,632.524
Set Internal Change=Bald Eagle      ,Loc Hav         ,114899.8, 15 , 3 ,632.11
Set Internal Change=Bald Eagle      ,Loc Hav         ,113985.6, 15 , 3 ,631.6573
Set Internal Change=Bald Eagle      ,Loc Hav         ,112856.9, 15 , 3 ,631.2759
Set Internal Change=Bald Eagle      ,Loc Hav         ,111971.0, 15 , 3 ,631.064
Set Internal Change=Bald Eagle      ,Loc Hav         ,110657.4, 15 , 3 ,630.8186
Set Internal Change=Bald Eagle      ,Loc Hav         ,109659.9, 15 , 3 ,630.6531
Set Internal Change=Bald Eagle      ,Loc Hav         ,108600.1, 15 , 3 ,630.5092
Set Internal Change=Bald Eagle      ,Loc Hav         ,107333.6, 15 , 3 ,630.3748
Set Internal Change=Bald Eagle      ,Loc Hav         ,106466.0, 15 , 3 ,630.3133
Set Internal Change=Bald Eagle      ,Loc Hav         ,105178.6, 15 , 3 ,630.2602
Set Internal Change=Bald Eagle      ,Loc Hav         ,104647.2, 15 , 3 ,630.2232
Set Internal Change=Bald Eagle      ,Loc Hav         ,104195.0, 15 , 3 ,630.2056
Set Internal Change=Bald Eagle      ,Loc Hav         ,103854.0, 15 , 3 ,630.1933
Set Internal Change=Bald Eagle      ,Loc Hav         ,103369.7, 15 , 3 ,630.1608
Set Internal Change=Bald Eagle      ,Loc Hav         ,103122.3, 15 , 3 ,630.0074
Set Internal Change=Bald Eagle      ,Loc Hav         ,101440.3, 15 , 3 ,629.9598
Set Internal Change=Bald Eagle      ,Loc Hav         ,100657.3, 15 , 3 ,629.9478
Set Internal Change=Bald Eagle      ,Loc Hav         ,99452.75, 15 , 3 ,629.939
Set Internal Change=Bald Eagle      ,Loc Hav         ,98206.87, 15 , 3 ,629.9349
Set Internal Change=Bald Eagle      ,Loc Hav         ,97607.35, 15 , 3 ,629.9194
Set Internal Change=Bald Eagle      ,Loc Hav         ,96370.43, 15 , 3 ,629.9139
Set Internal Change=Bald Eagle      ,Loc Hav         ,94560.01, 15 , 3 ,629.9098
Set Internal Change=Bald Eagle      ,Loc Hav         ,93391.71, 15 , 3 ,629.907
Set Internal Change=Bald Eagle      ,Loc Hav         ,92011.85, 15 , 3 ,629.9039
Set Internal Change=Bald Eagle      ,Loc Hav         ,91030.01, 15 , 3 ,629.9019
Set Internal Change=Bald Eagle      ,Loc Hav         ,90096.99, 15 , 3 ,629.9017
Set Internal Change=Bald Eagle      ,Loc Hav         ,89060.69, 15 , 3 ,629.9012
Set Internal Change=Bald Eagle      ,Loc Hav         ,87861.14, 15 , 3 ,629.9011
Set Internal Change=Bald Eagle      ,Loc Hav         ,86942.04, 15 , 3 ,629.9012
Set Internal Change=Bald Eagle      ,Loc Hav         ,85569.53, 15 , 3 ,629.9012
Set Internal Change=Bald Eagle      ,Loc Hav         ,84724.08, 15 , 3 ,629.9011
Set Internal Change=Bald Eagle      ,Loc Hav         ,83563.41, 15 , 3 ,629.9011
Set Internal Change=Bald Eagle      ,Loc Hav         ,82607.89, 15 , 3 ,629.9011
Set Internal Change=Bald Eagle      ,Loc Hav         ,81849.41, 15 , 3 ,629.9006
Set Internal Change=Bald Eagle      ,Loc Hav         ,81084.18, 15 , 3 ,592.6448
Set Internal Change=Bald Eagle      ,Loc Hav         ,80500.50, 15 , 3 ,590.8855
Set Internal Change=Bald Eagle      ,Loc Hav         ,79684.28, 15 , 3 ,589.9369
Set Internal Change=Bald Eagle      ,Loc Hav         ,78627.87, 15 , 3 ,589.3024
Set Internal Change=Bald Eagle      ,Loc Hav         ,76643.40, 15 , 3 ,587.8213
Set Internal Change=Bald Eagle      ,Loc Hav         ,76002.96, 15 , 3 ,587.1108
Set Internal Change=Bald Eagle      ,Loc Hav         ,75917.82, 15 , 3 ,586.9635
Set Internal Change=Bald Eagle      ,Loc Hav         ,75616.14, 15 , 3 ,586.4807
Set Internal Change=Bald Eagle      ,Loc Hav         ,74650.60, 15 , 3 ,585.4302
Set Internal Change=Bald Eagle      ,Loc Hav         ,74207.96, 15 , 3 ,585.0513
Set Internal Change=Bald Eagle      ,Loc Hav         ,73504.24, 15 , 3 ,584.4982
Set Internal Change=Bald Eagle      ,Loc Hav         ,72303.68, 15 , 3 ,583.7986
Set Internal Change=Bald Eagle      ,Loc Hav         ,71400.81, 15 , 3 ,583.1368
Set Internal Change=Bald Eagle      ,Loc Hav         ,70651.52, 15 , 3 ,582.5384
Set Internal Change=Bald Eagle      ,Loc Hav         ,69567.33, 15 , 3 ,581.6699
Set Internal Change=Bald Eagle      ,Loc Hav         ,68604.09, 15 , 3 ,581.0341
Set Internal Change=Bald Eagle      ,Loc Hav         ,67326.78, 15 , 3 ,580.2999
Set Internal Change=Bald Eagle      ,Loc Hav         ,66070.17, 15 , 3 ,579.2203
Set Internal Change=Bald Eagle      ,Loc Hav         ,64908.02, 15 , 3 ,577.9063
Set Internal Change=Bald Eagle      ,Loc Hav         ,63812.99, 15 , 3 ,576.502
Set Internal Change=Bald Eagle      ,Loc Hav         ,62746.41, 15 , 3 ,575.4664
Set Internal Change=Bald Eagle      ,Loc Hav         ,61896.89, 15 , 3 ,574.7697
Set Internal Change=Bald Eagle      ,Loc Hav         ,60901.09, 15 , 3 ,573.8016
Set Internal Change=Bald Eagle      ,Loc Hav         ,59795.28, 15 , 3 ,572.8214
Set Internal Change=Bald Eagle      ,Loc Hav         ,58836.23, 15 , 3 ,572.1641
Set Internal Change=Bald Eagle      ,Loc Hav         ,58708.54, 15 , 3 ,572.0781
Set Internal Change=Bald Eagle      ,Loc Hav         ,58091.91, 15 , 3 ,571.7763
Set Internal Change=Bald Eagle      ,Loc Hav         ,57700.27, 15 , 3 ,571.4838
Set Internal Change=Bald Eagle      ,Loc Hav         ,57250.60, 15 , 3 ,571.2264
Set Internal Change=Bald Eagle      ,Loc Hav         ,56775.92, 15 , 3 ,570.8062
Set Internal Change=Bald Eagle      ,Loc Hav         ,56243.79, 15 , 3 ,570.4865
Set Internal Change=Bald Eagle      ,Loc Hav         ,55700.55, 15 , 3 ,570.1025
Set Internal Change=Bald Eagle      ,Loc Hav         ,54696.51, 15 , 3 ,569.4073
Set Internal Change=Bald Eagle      ,Loc Hav         ,53922.53, 15 , 3 ,568.8
Set Internal Change=Bald Eagle      ,Loc Hav         ,52879.19, 15 , 3 ,568.0898
Set Internal Change=Bald Eagle      ,Loc Hav         ,51784.74, 15 , 3 ,567.4155
Set Internal Change=Bald Eagle      ,Loc Hav         ,50720.68, 15 , 3 ,566.9109
Set Internal Change=Bald Eagle      ,Loc Hav         ,49715.77, 15 , 3 ,566.7039
Set Internal Change=Bald Eagle      ,Loc Hav         ,48965.94, 15 , 3 ,566.5074
Set Internal Change=Bald Eagle      ,Loc Hav         ,48110.09, 15 , 3 ,565.3852
Set Internal Change=Bald Eagle      ,Loc Hav         ,47453.14, 15 , 3 ,564.5626
Set Internal Change=Bald Eagle      ,Loc Hav         ,46722.59, 15 , 3 ,563.9054
Set Internal Change=Bald Eagle      ,Loc Hav         ,46310.48, 15 , 3 ,563.6769
Set Internal Change=Bald Eagle      ,Loc Hav         ,45805.37, 15 , 3 ,563.4053
Set Internal Change=Bald Eagle      ,Loc Hav         ,45233.89, 15 , 3 ,563.0925
Set Internal Change=Bald Eagle      ,Loc Hav         ,44529.29, 15 , 3 ,562.6614
Set Internal Change=Bald Eagle      ,Loc Hav         ,43919.30, 15 , 3 ,562.386
Set Internal Change=Bald Eagle      ,Loc Hav         ,42895.87, 15 , 3 ,561.9048
Set Internal Change=Bald Eagle      ,Loc Hav         ,41806.43, 15 , 3 ,561.4084
Set Internal Change=Bald Eagle      ,Loc Hav         ,40526.85, 15 , 3 ,561.0747
Set Internal Change=Bald Eagle      ,Loc Hav         ,39499.37, 15 , 3 ,560.9007
Set Internal Change=Bald Eagle      ,Loc Hav         ,38446.87, 15 , 3 ,560.5823
Set Internal Change=Bald Eagle      ,Loc Hav         ,37962.54, 15 , 3 ,560.3867
Set Internal Change=Bald Eagle      ,Loc Hav         ,37385.23, 15 , 3 ,560.1826
Set Internal Change=Bald Eagle      ,Loc Hav         ,36769.88, 15 , 3 ,560.0112
Set Internal Change=Bald Eagle      ,Loc Hav         ,36663.76, 15 , 3 ,559.9119
Set Internal Change=Bald Eagle      ,Loc Hav         ,36339.56, 15 , 3 ,559.7416
Set Internal Change=Bald Eagle      ,Loc Hav         ,35648.50, 15 , 3 ,559.3807
Set Internal Change=Bald Eagle      ,Loc Hav         ,35072.37, 15 , 3 ,559.1973
Set Internal Change=Bald Eagle      ,Loc Hav         ,34098.93, 15 , 3 ,558.9461
Set Internal Change=Bald Eagle      ,Loc Hav         ,33498.68, 15 , 3 ,558.7617
Set Internal Change=Bald Eagle      ,Loc Hav         ,32195.47, 15 , 3 ,557.7187
Set Internal Change=Bald Eagle      ,Loc Hav         ,30878.12, 15 , 3 ,556.7993
Set Internal Change=Bald Eagle      ,Loc Hav         ,29563.77, 15 , 3 ,556.2326
Set Internal Change=Bald Eagle      ,Loc Hav         ,27226.40, 15 , 3 ,553.502
Set Internal Change=Bald Eagle      ,Loc Hav         ,25960.70, 15 , 3 ,551.3275
Set Internal Change=Bald Eagle      ,Loc Hav         ,24843.25, 15 , 3 ,550.3212
Set Internal Change=Bald Eagle      ,Loc Hav         ,24417.73, 15 , 3 ,550.0782
Set Internal Change=Bald Eagle      ,Loc Hav         ,23872.06, 15 , 3 ,549.1883
Set Internal Change=Bald Eagle      ,Loc Hav         ,23783.65, 15 , 3 ,549.1591
Set Internal Change=Bald Eagle      ,Loc Hav         ,23384.79, 15 , 3 ,548.9736
Set Internal Change=Bald Eagle      ,Loc Hav         ,22982.97, 15 , 3 ,548.781
Set Internal Change=Bald Eagle      ,Loc Hav         ,22386.15, 15 , 3 ,548.3399
Set Internal Change=Bald Eagle      ,Loc Hav         ,21283.34, 15 , 3 ,547.8011
Set Internal Change=Bald Eagle      ,Loc Hav         ,21199.93, 15 , 3 ,547.7785
Set Internal Change=Bald Eagle      ,Loc Hav         ,20127.30, 15 , 3 ,547.2836
Set Internal Change=Bald Eagle      ,Loc Hav         ,19036.24, 15 , 3 ,546.033
Set Internal Change=Bald Eagle      ,Loc Hav         ,18200.10, 15 , 3 ,545.4423
Set Internal Change=Bald Eagle      ,Loc Hav         ,17549.23, 15 , 3 ,545.3072
Set Internal Change=Bald Eagle      ,Loc Hav         ,16787.45, 15 , 3 ,545.1158
Set Internal Change=Bald Eagle      ,Loc Hav         ,15407.88, 15 , 3 ,544.5498
Set Internal Change=Bald Eagle      ,Loc Hav         ,14814.34, 15 , 3 ,544.1003
Set Internal Change=Bald Eagle      ,Loc Hav         ,13326.74, 15 , 3 ,543.4794
Set Internal Change=Bald Eagle      ,Loc Hav         ,12035.22, 15 , 3 ,543.1315
Set Internal Change=Bald Eagle      ,Loc Hav         ,11865.80, 15 , 3 ,543.0898
Set Internal Change=Bald Eagle      ,Loc Hav         ,11116.44, 15 , 3 ,542.7211
Set Internal Change=Bald Eagle      ,Loc Hav         ,10995.73, 15 , 3 ,542.6635
Set Internal Change=Bald Eagle      ,Loc Hav         ,10221.14, 15 , 3 ,542.2082
Set Internal Change=Bald Eagle      ,Loc Hav         ,9258.941, 15 , 3 ,541.8384
Set Internal Change=Bald Eagle      ,Loc Hav         ,8541.462, 15 , 3 ,541.7101
Set Internal Change=Bald Eagle      ,Loc Hav         ,7936.130, 15 , 3 ,541.5684
Set Internal Change=Bald Eagle      ,Loc Hav         ,6940.066, 15 , 3 ,541.2705
Set Internal Change=Bald Eagle      ,Loc Hav         ,6267.489, 15 , 3 ,541.0911
Set Internal Change=Bald Eagle      ,Loc Hav         ,5523.234, 15 , 3 ,540.9304
Set Internal Change=Bald Eagle      ,Loc Hav         ,4293.710, 15 , 3 ,540.6476
Set Internal Change=Bald Eagle      ,Loc Hav         ,3047.378, 15 , 3 ,540.3618
Set Internal Change=Bald Eagle      ,Loc Hav         ,2731.142, 15 , 3 ,540.2507
Set Internal Change=Bald Eagle      ,Loc Hav         ,2501.017, 15 , 3 ,540.2457
Set Internal Change=Bald Eagle      ,Loc Hav         ,2371.827, 15 , 3 ,540.2298
Set Internal Change=Bald Eagle      ,Loc Hav         ,1692.633, 15 , 3 ,540.1848
Set Internal Change=Bald Eagle      ,Loc Hav         ,1212.855, 15 , 3 ,540.1521
Set Internal Change=Bald Eagle      ,Loc Hav         ,659.942 , 15 , 3 ,540.1089
Set Internal Change=Bald Eagle      ,Loc Hav         ,138154.4, 16 , 3 ,670.6494
Set Internal Change=Bald Eagle      ,Loc Hav         ,137690.8, 16 , 3 ,670.4159
Set Internal Change=Bald Eagle      ,Loc Hav         ,137327.0, 16 , 3 ,669.9662
Set Internal Change=Bald Eagle      ,Loc Hav         ,136564.9, 16 , 3 ,666.7733
Set Internal Change=Bald Eagle      ,Loc Hav         ,136202.3, 16 , 3 ,666.264
Set Internal Change=Bald Eagle      ,Loc Hav         ,135591.4, 16 , 3 ,664.6658
Set Internal Change=Bald Eagle      ,Loc Hav         ,135068.7, 16 , 3 ,664.0732
Set Internal Change=Bald Eagle      ,Loc Hav         ,134487.2, 16 , 3 ,663.0282
Set Internal Change=Bald Eagle      ,Loc Hav         ,133881.0, 16 , 3 ,662.2917
Set Internal Change=Bald Eagle      ,Loc Hav         ,133446.1, 16 , 3 ,661.6924
Set Internal Change=Bald Eagle      ,Loc Hav         ,132973.6, 16 , 3 ,661.0884
Set Internal Change=Bald Eagle      ,Loc Hav         ,132363.8, 16 , 3 ,659.6266
Set Internal Change=Bald Eagle      ,Loc Hav         ,131699.7, 16 , 3 ,657.4948
Set Internal Change=Bald Eagle      ,Loc Hav         ,130997.6, 16 , 3 ,655.484
Set Internal Change=Bald Eagle      ,Loc Hav         ,130339.2, 16 , 3 ,653.9474
Set Internal Change=Bald Eagle      ,Loc Hav         ,129627.5, 16 , 3 ,652.399
Set Internal Change=Bald Eagle      ,Loc Hav         ,128760.7, 16 , 3 ,650.9779
Set Internal Change=Bald Eagle      ,Loc Hav         ,128280.7, 16 , 3 ,650.4922
Set Internal Change=Bald Eagle      ,Loc Hav         ,127410.9, 16 , 3 ,649.8332
Set Internal Change=Bald Eagle      ,Loc Hav         ,126741.0, 16 , 3 ,649.1219
Set Internal Change=Bald Eagle      ,Loc Hav         ,126454.1, 16 , 3 ,648.4418
Set Internal Change=Bald Eagle      ,Loc Hav         ,126062.6, 16 , 3 ,647.6832
Set Internal Change=Bald Eagle      ,Loc Hav         ,125704.7, 16 , 3 ,647.0992
Set Internal Change=Bald Eagle      ,Loc Hav         ,125091.9, 16 , 3 ,646.1544
Set Internal Change=Bald Eagle      ,Loc Hav         ,124615.5, 16 , 3 ,645.6766
Set Internal Change=Bald Eagle      ,Loc Hav         ,124025.0, 16 , 3 ,644.4018
Set Internal Change=Bald Eagle      ,Loc Hav         ,123503.5, 16 , 3 ,643.4502
Set Internal Change=Bald Eagle      ,Loc Hav         ,123123.6, 16 , 3 ,642.9013
Set Internal Change=Bald Eagle      ,Loc Hav         ,122703.3, 16 , 3 ,642.3949
Set Internal Change=Bald Eagle      ,Loc Hav         ,122190.8, 16 , 3 ,641.738
Set Internal Change=Bald Eagle      ,Loc Hav         ,121754.0, 16 , 3 ,641.2442
Set Internal Change=Bald Eagle      ,Loc Hav         ,121394.1, 16 , 3 ,640.902
Set Internal Change=Bald Eagle      ,Loc Hav         ,120862.6, 16 , 3 ,640.3361
Set Internal Change=Bald Eagle      ,Loc Hav         ,120421.4, 16 , 3 ,639.554
Set Internal Change=Bald Eagle      ,Loc Hav         ,119954.9, 16 , 3 ,638.8083
Set Internal Change=Bald Eagle      ,Loc Hav         ,119473.8, 16 , 3 ,637.8717
Set Internal Change=Bald Eagle      ,Loc Hav         ,118901.0, 16 , 3 ,636.6243
Set Internal Change=Bald Eagle      ,Loc Hav         ,118300.5, 16 , 3 ,635.7365
Set Internal Change=Bald Eagle      ,Loc Hav         ,117753.9, 16 , 3 ,635.2463
Set Internal Change=Bald Eagle      ,Loc Hav         ,117180.8, 16 , 3 ,634.7649
Set Internal Change=Bald Eagle      ,Loc Hav         ,116401.3, 16 , 3 ,634.3975
Set Internal Change=Bald Eagle      ,Loc Hav         ,115584.2, 16 , 3 ,634.1281
Set Internal Change=Bald Eagle      ,Loc Hav         ,114899.8, 16 , 3 ,633.9059
Set Internal Change=Bald Eagle      ,Loc Hav         ,113985.6, 16 , 3 ,633.6605
Set Internal Change=Bald Eagle      ,Loc Hav         ,112856.9, 16 , 3 ,633.4454
Set Internal Change=Bald Eagle      ,Loc Hav         ,111971.0, 16 , 3 ,633.3342
Set Internal Change=Bald Eagle      ,Loc Hav         ,110657.4, 16 , 3 ,633.2032
Set Internal Change=Bald Eagle      ,Loc Hav         ,109659.9, 16 , 3 ,633.1102
Set Internal Change=Bald Eagle      ,Loc Hav         ,108600.1, 16 , 3 ,633.0292
Set Internal Change=Bald Eagle      ,Loc Hav         ,107333.6, 16 , 3 ,632.9524
Set Internal Change=Bald Eagle      ,Loc Hav         ,106466.0, 16 , 3 ,632.9175
Set Internal Change=Bald Eagle      ,Loc Hav         ,105178.6, 16 , 3 ,632.8862
Set Internal Change=Bald Eagle      ,Loc Hav         ,104647.2, 16 , 3 ,632.8622
Set Internal Change=Bald Eagle      ,Loc Hav         ,104195.0, 16 , 3 ,632.8523
Set Internal Change=Bald Eagle      ,Loc Hav         ,103854.0, 16 , 3 ,632.8446
Set Internal Change=Bald Eagle      ,Loc Hav         ,103369.7, 16 , 3 ,632.8228
Set Internal Change=Bald Eagle      ,Loc Hav         ,103122.3, 16 , 3 ,632.7072
Set Internal Change=Bald Eagle      ,Loc Hav         ,101440.3, 16 , 3 ,632.6802
Set Internal Change=Bald Eagle      ,Loc Hav         ,100657.3, 16 , 3 ,632.6729
Set Internal Change=Bald Eagle      ,Loc Hav         ,99452.75, 16 , 3 ,632.6674
Set Internal Change=Bald Eagle      ,Loc Hav         ,98206.87, 16 , 3 ,632.6653
Set Internal Change=Bald Eagle      ,Loc Hav         ,97607.35, 16 , 3 ,632.6552
Set Internal Change=Bald Eagle      ,Loc Hav         ,96370.43, 16 , 3 ,632.6531
Set Internal Change=Bald Eagle      ,Loc Hav         ,94560.01, 16 , 3 ,632.6505
Set Internal Change=Bald Eagle      ,Loc Hav         ,93391.71, 16 , 3 ,632.6483
Set Internal Change=Bald Eagle      ,Loc Hav         ,92011.85, 16 , 3 ,632.6461
Set Internal Change=Bald Eagle      ,Loc Hav         ,91030.01, 16 , 3 ,632.6448
Set Internal Change=Bald Eagle      ,Loc Hav         ,90096.99, 16 , 3 ,632.6449
Set Internal Change=Bald Eagle      ,Loc Hav         ,89060.69, 16 , 3 ,632.6446
Set Internal Change=Bald Eagle      ,Loc Hav         ,87861.14, 16 , 3 ,632.6447
Set Internal Change=Bald Eagle      ,Loc Hav         ,86942.04, 16 , 3 ,632.6447
Set Internal Change=Bald Eagle      ,Loc Hav         ,85569.53, 16 , 3 ,632.6449
Set Internal Change=Bald Eagle      ,Loc Hav         ,84724.08, 16 , 3 ,632.6448
Set Internal Change=Bald Eagle      ,Loc Hav         ,83563.41, 16 , 3 ,632.6448
Set Internal Change=Bald Eagle      ,Loc Hav         ,82607.89, 16 , 3 ,632.6448
Set Internal Change=Bald Eagle      ,Loc Hav         ,81849.41, 16 , 3 ,632.6444
Set Internal Change=Bald Eagle      ,Loc Hav         ,81084.18, 16 , 3 ,592.9471
Set Internal Change=Bald Eagle      ,Loc Hav         ,80500.50, 16 , 3 ,591.1636
Set Internal Change=Bald Eagle      ,Loc Hav         ,79684.28, 16 , 3 ,590.1896
Set Internal Change=Bald Eagle      ,Loc Hav         ,78627.87, 16 , 3 ,589.5272
Set Internal Change=Bald Eagle      ,Loc Hav         ,76643.40, 16 , 3 ,588.0115
Set Internal Change=Bald Eagle      ,Loc Hav         ,76002.96, 16 , 3 ,587.2596
Set Internal Change=Bald Eagle      ,Loc Hav         ,75917.82, 16 , 3 ,587.0999
Set Internal Change=Bald Eagle      ,Loc Hav         ,75616.14, 16 , 3 ,586.6496
Set Internal Change=Bald Eagle      ,Loc Hav         ,74650.60, 16 , 3 ,585.5839
Set Internal Change=Bald Eagle      ,Loc Hav         ,74207.96, 16 , 3 ,585.209
Set Internal Change=Bald Eagle      ,Loc Hav         ,73504.24, 16 , 3 ,584.6764
Set Internal Change=Bald Eagle      ,Loc Hav         ,72303.68, 16 , 3 ,584.0125
Set Internal Change=Bald Eagle      ,Loc Hav         ,71400.81, 16 , 3 ,583.3934
Set Internal Change=Bald Eagle      ,Loc Hav         ,70651.52, 16 , 3 ,582.8148
Set Internal Change=Bald Eagle      ,Loc Hav         ,69567.33, 16 , 3 ,581.9399
Set Internal Change=Bald Eagle      ,Loc Hav         ,68604.09, 16 , 3 ,581.2841
Set Internal Change=Bald Eagle      ,Loc Hav         ,67326.78, 16 , 3 ,580.5392
Set Internal Change=Bald Eagle      ,Loc Hav         ,66070.17, 16 , 3 ,579.4802
Set Internal Change=Bald Eagle      ,Loc Hav         ,64908.02, 16 , 3 ,578.1817
Set Internal Change=Bald Eagle      ,Loc Hav         ,63812.99, 16 , 3 ,576.7615
Set Internal Change=Bald Eagle      ,Loc Hav         ,62746.41, 16 , 3 ,575.7401
Set Internal Change=Bald Eagle      ,Loc Hav         ,61896.89, 16 , 3 ,575.074
Set Internal Change=Bald Eagle      ,Loc Hav         ,60901.09, 16 , 3 ,574.119
Set Internal Change=Bald Eagle      ,Loc Hav         ,59795.28, 16 , 3 ,573.1141
Set Internal Change=Bald Eagle      ,Loc Hav         ,58836.23, 16 , 3 ,572.4355
Set Internal Change=Bald Eagle      ,Loc Hav         ,58708.54, 16 , 3 ,572.345
Set Internal Change=Bald Eagle      ,Loc Hav         ,58091.91, 16 , 3 ,572.0562
Set Internal Change=Bald Eagle      ,Loc Hav         ,57700.27, 16 , 3 ,571.7646
Set Internal Change=Bald Eagle      ,Loc Hav         ,57250.60, 16 , 3 ,571.5002
Set Internal Change=Bald Eagle      ,Loc Hav         ,56775.92, 16 , 3 ,571.0807
Set Internal Change=Bald Eagle      ,Loc Hav         ,56243.79, 16 , 3 ,570.7534
Set Internal Change=Bald Eagle      ,Loc Hav         ,55700.55, 16 , 3 ,570.3837
Set Internal Change=Bald Eagle      ,Loc Hav         ,54696.51, 16 , 3 ,569.6929
Set Internal Change=Bald Eagle      ,Loc Hav         ,53922.53, 16 , 3 ,569.0739
Set Internal Change=Bald Eagle      ,Loc Hav         ,52879.19, 16 , 3 ,568.3526
Set Internal Change=Bald Eagle      ,Loc Hav         ,51784.74, 16 , 3 ,567.6672
Set Internal Change=Bald Eagle      ,Loc Hav         ,50720.68, 16 , 3 ,567.1317
Set Internal Change=Bald Eagle      ,Loc Hav         ,49715.77, 16 , 3 ,566.9124
Set Internal Change=Bald Eagle      ,Loc Hav         ,48965.94, 16 , 3 ,566.7046
Set Internal Change=Bald Eagle      ,Loc Hav         ,48110.09, 16 , 3 ,565.7261
Set Internal Change=Bald Eagle      ,Loc Hav         ,47453.14, 16 , 3 ,564.8766
Set Internal Change=Bald Eagle      ,Loc Hav         ,46722.59, 16 , 3 ,564.1993
Set Internal Change=Bald Eagle      ,Loc Hav         ,46310.48, 16 , 3 ,563.9735
Set Internal Change=Bald Eagle      ,Loc Hav         ,45805.37, 16 , 3 ,563.6931
Set Internal Change=Bald Eagle      ,Loc Hav         ,45233.89, 16 , 3 ,563.3634
Set Internal Change=Bald Eagle      ,Loc Hav         ,44529.29, 16 , 3 ,562.9152
Set Internal Change=Bald Eagle      ,Loc Hav         ,43919.30, 16 , 3 ,562.6281
Set Internal Change=Bald Eagle      ,Loc Hav         ,42895.87, 16 , 3 ,562.1678
Set Internal Change=Bald Eagle      ,Loc Hav         ,41806.43, 16 , 3 ,561.6996
Set Internal Change=Bald Eagle      ,Loc Hav         ,40526.85, 16 , 3 ,561.3864
Set Internal Change=Bald Eagle      ,Loc Hav         ,39499.37, 16 , 3 ,561.2263
Set Internal Change=Bald Eagle      ,Loc Hav         ,38446.87, 16 , 3 ,560.9203
Set Internal Change=Bald Eagle      ,Loc Hav         ,37962.54, 16 , 3 ,560.7337
Set Internal Change=Bald Eagle      ,Loc Hav         ,37385.23, 16 , 3 ,560.5324
Set Internal Change=Bald Eagle      ,Loc Hav         ,36769.88, 16 , 3 ,560.3485
Set Internal Change=Bald Eagle      ,Loc Hav         ,36663.76, 16 , 3 ,560.2397
Set Internal Change=Bald Eagle      ,Loc Hav         ,36339.56, 16 , 3 ,560.077
Set Internal Change=Bald Eagle      ,Loc Hav         ,35648.50, 16 , 3 ,559.7092
Set Internal Change=Bald Eagle      ,Loc Hav         ,35072.37, 16 , 3 ,559.5248
Set Internal Change=Bald Eagle      ,Loc Hav         ,34098.93, 16 , 3 ,559.2761
Set Internal Change=Bald Eagle      ,Loc Hav         ,33498.68, 16 , 3 ,559.098
Set Internal Change=Bald Eagle      ,Loc Hav         ,32195.47, 16 , 3 ,558.0147
Set Internal Change=Bald Eagle      ,Loc Hav         ,30878.12, 16 , 3 ,557.0632
Set Internal Change=Bald Eagle      ,Loc Hav         ,29563.77, 16 , 3 ,556.5044
Set Internal Change=Bald Eagle      ,Loc Hav         ,27226.40, 16 , 3 ,553.6834
Set Internal Change=Bald Eagle      ,Loc Hav         ,25960.70, 16 , 3 ,551.5374
Set Internal Change=Bald Eagle      ,Loc Hav         ,24843.25, 16 , 3 ,550.5906
Set Internal Change=Bald Eagle      ,Loc Hav         ,24417.73, 16 , 3 ,550.3439
Set Internal Change=Bald Eagle      ,Loc Hav         ,23872.06, 16 , 3 ,549.4625
Set Internal Change=Bald Eagle      ,Loc Hav         ,23783.65, 16 , 3 ,549.4332
Set Internal Change=Bald Eagle      ,Loc Hav         ,23384.79, 16 , 3 ,549.2605
Set Internal Change=Bald Eagle      ,Loc Hav         ,22982.97, 16 , 3 ,549.0808
Set Internal Change=Bald Eagle      ,Loc Hav         ,22386.15, 16 , 3 ,548.6554
Set Internal Change=Bald Eagle      ,Loc Hav         ,21283.34, 16 , 3 ,548.1157
Set Internal Change=Bald Eagle      ,Loc Hav         ,21199.93, 16 , 3 ,548.0853
Set Internal Change=Bald Eagle      ,Loc Hav         ,20127.30, 16 , 3 ,547.5822
Set Internal Change=Bald Eagle      ,Loc Hav         ,19036.24, 16 , 3 ,546.4103
Set Internal Change=Bald Eagle      ,Loc Hav         ,18200.10, 16 , 3 ,545.884
Set Internal Change=Bald Eagle      ,Loc Hav         ,17549.23, 16 , 3 ,545.7522
Set Internal Change=Bald Eagle      ,Loc Hav         ,16787.45, 16 , 3 ,545.5609
Set Internal Change=Bald Eagle      ,Loc Hav         ,15407.88, 16 , 3 ,545.0041
Set Internal Change=Bald Eagle      ,Loc Hav         ,14814.34, 16 , 3 ,544.5427
Set Internal Change=Bald Eagle      ,Loc Hav         ,13326.74, 16 , 3 ,543.9426
Set Internal Change=Bald Eagle      ,Loc Hav         ,12035.22, 16 , 3 ,543.6011
Set Internal Change=Bald Eagle      ,Loc Hav         ,11865.80, 16 , 3 ,543.5595
Set Internal Change=Bald Eagle      ,Loc Hav         ,11116.44, 16 , 3 ,543.2004
Set Internal Change=Bald Eagle      ,Loc Hav         ,10995.73, 16 , 3 ,543.1461
Set Internal Change=Bald Eagle      ,Loc Hav         ,10221.14, 16 , 3 ,542.733
Set Internal Change=Bald Eagle      ,Loc Hav         ,9258.941, 16 , 3 ,542.3994
Set Internal Change=Bald Eagle      ,Loc Hav         ,8541.462, 16 , 3 ,542.2764
Set Internal Change=Bald Eagle      ,Loc Hav         ,7936.130, 16 , 3 ,542.1384
Set Internal Change=Bald Eagle      ,Loc Hav         ,6940.066, 16 , 3 ,541.8438
Set Internal Change=Bald Eagle      ,Loc Hav         ,6267.489, 16 , 3 ,541.6707
Set Internal Change=Bald Eagle      ,Loc Hav         ,5523.234, 16 , 3 ,541.5084
Set Internal Change=Bald Eagle      ,Loc Hav         ,4293.710, 16 , 3 ,541.2233
Set Internal Change=Bald Eagle      ,Loc Hav         ,3047.378, 16 , 3 ,540.939
Set Internal Change=Bald Eagle      ,Loc Hav         ,2731.142, 16 , 3 ,540.827
Set Internal Change=Bald Eagle      ,Loc Hav         ,2501.017, 16 , 3 ,540.8246
Set Internal Change=Bald Eagle      ,Loc Hav         ,2371.827, 16 , 3 ,540.8082
Set Internal Change=Bald Eagle      ,Loc Hav         ,1692.633, 16 , 3 ,540.7605
Set Internal Change=Bald Eagle      ,Loc Hav         ,1212.855, 16 , 3 ,540.7255
Set Internal Change=Bald Eagle      ,Loc Hav         ,659.942 , 16 , 3 ,540.6846
Set Internal Change=Bald Eagle      ,Loc Hav         ,138154.4, 17 , 3 ,671.0575
Set Internal Change=Bald Eagle      ,Loc Hav         ,137690.8, 17 , 3 ,670.8446
Set Internal Change=Bald Eagle      ,Loc Hav         ,137327.0, 17 , 3 ,670.3887
Set Internal Change=Bald Eagle      ,Loc Hav         ,136564.9, 17 , 3 ,667.145
Set Internal Change=Bald Eagle      ,Loc Hav         ,136202.3, 17 , 3 ,666.6441
Set Internal Change=Bald Eagle      ,Loc Hav         ,135591.4, 17 , 3 ,665.0015
Set Internal Change=Bald Eagle      ,Loc Hav         ,135068.7, 17 , 3 ,664.431
Set Internal Change=Bald Eagle      ,Loc Hav         ,134487.2, 17 , 3 ,663.3898
Set Internal Change=Bald Eagle      ,Loc Hav         ,133881.0, 17 , 3 ,662.6553
Set Internal Change=Bald Eagle      ,Loc Hav         ,133446.1, 17 , 3 ,662.0456
Set Internal Change=Bald Eagle      ,Loc Hav         ,132973.6, 17 , 3 ,661.4398
Set Internal Change=Bald Eagle      ,Loc Hav         ,132363.8, 17 , 3 ,659.9442
Set Internal Change=Bald Eagle      ,Loc Hav         ,131699.7, 17 , 3 ,657.7797
Set Internal Change=Bald Eagle      ,Loc Hav         ,130997.6, 17 , 3 ,655.7503
Set Internal Change=Bald Eagle      ,Loc Hav         ,130339.2, 17 , 3 ,654.2129
Set Internal Change=Bald Eagle      ,Loc Hav         ,129627.5, 17 , 3 ,652.6945
Set Internal Change=Bald Eagle      ,Loc Hav         ,128760.7, 17 , 3 ,651.3257
Set Internal Change=Bald Eagle      ,Loc Hav         ,128280.7, 17 , 3 ,650.8649
Set Internal Change=Bald Eagle      ,Loc Hav         ,127410.9, 17 , 3 ,650.223
Set Internal Change=Bald Eagle      ,Loc Hav         ,126741.0, 17 , 3 ,649.5106
Set Internal Change=Bald Eagle      ,Loc Hav         ,126454.1, 17 , 3 ,648.8231
Set Internal Change=Bald Eagle      ,Loc Hav         ,126062.6, 17 , 3 ,648.0623
Set Internal Change=Bald Eagle      ,Loc Hav         ,125704.7, 17 , 3 ,647.4809
Set Internal Change=Bald Eagle      ,Loc Hav         ,125091.9, 17 , 3 ,646.5452
Set Internal Change=Bald Eagle      ,Loc Hav         ,124615.5, 17 , 3 ,646.0724
Set Internal Change=Bald Eagle      ,Loc Hav         ,124025.0, 17 , 3 ,644.8127
Set Internal Change=Bald Eagle      ,Loc Hav         ,123503.5, 17 , 3 ,643.8843
Set Internal Change=Bald Eagle      ,Loc Hav         ,123123.6, 17 , 3 ,643.3527
Set Internal Change=Bald Eagle      ,Loc Hav         ,122703.3, 17 , 3 ,642.8622
Set Internal Change=Bald Eagle      ,Loc Hav         ,122190.8, 17 , 3 ,642.2318
Set Internal Change=Bald Eagle      ,Loc Hav         ,121754.0, 17 , 3 ,641.7631
Set Internal Change=Bald Eagle      ,Loc Hav         ,121394.1, 17 , 3 ,641.4371
Set Internal Change=Bald Eagle      ,Loc Hav         ,120862.6, 17 , 3 ,640.9073
Set Internal Change=Bald Eagle      ,Loc Hav         ,120421.4, 17 , 3 ,640.1834
Set Internal Change=Bald Eagle      ,Loc Hav         ,119954.9, 17 , 3 ,639.5053
Set Internal Change=Bald Eagle      ,Loc Hav         ,119473.8, 17 , 3 ,638.7004
Set Internal Change=Bald Eagle      ,Loc Hav         ,118901.0, 17 , 3 ,637.736
Set Internal Change=Bald Eagle      ,Loc Hav         ,118300.5, 17 , 3 ,637.1025
Set Internal Change=Bald Eagle      ,Loc Hav         ,117753.9, 17 , 3 ,636.7971
Set Internal Change=Bald Eagle      ,Loc Hav         ,117180.8, 17 , 3 ,636.5538
Set Internal Change=Bald Eagle      ,Loc Hav         ,116401.3, 17 , 3 ,636.3757
Set Internal Change=Bald Eagle      ,Loc Hav         ,115584.2, 17 , 3 ,636.2288
Set Internal Change=Bald Eagle      ,Loc Hav         ,114899.8, 17 , 3 ,636.1107
Set Internal Change=Bald Eagle      ,Loc Hav         ,113985.6, 17 , 3 ,635.9731
Set Internal Change=Bald Eagle      ,Loc Hav         ,112856.9, 17 , 3 ,635.8503
Set Internal Change=Bald Eagle      ,Loc Hav         ,111971.0, 17 , 3 ,635.7913
Set Internal Change=Bald Eagle      ,Loc Hav         ,110657.4, 17 , 3 ,635.7166
Set Internal Change=Bald Eagle      ,Loc Hav         ,109659.9, 17 , 3 ,635.6595
Set Internal Change=Bald Eagle      ,Loc Hav         ,108600.1, 17 , 3 ,635.6103
Set Internal Change=Bald Eagle      ,Loc Hav         ,107333.6, 17 , 3 ,635.5625
Set Internal Change=Bald Eagle      ,Loc Hav         ,106466.0, 17 , 3 ,635.5406
Set Internal Change=Bald Eagle      ,Loc Hav         ,105178.6, 17 , 3 ,635.5206
Set Internal Change=Bald Eagle      ,Loc Hav         ,104647.2, 17 , 3 ,635.5038
Set Internal Change=Bald Eagle      ,Loc Hav         ,104195.0, 17 , 3 ,635.4976
Set Internal Change=Bald Eagle      ,Loc Hav         ,103854.0, 17 , 3 ,635.4924
Set Internal Change=Bald Eagle      ,Loc Hav         ,103369.7, 17 , 3 ,635.4774
Set Internal Change=Bald Eagle      ,Loc Hav         ,103122.3, 17 , 3 ,635.3874
Set Internal Change=Bald Eagle      ,Loc Hav         ,101440.3, 17 , 3 ,635.3704
Set Internal Change=Bald Eagle      ,Loc Hav         ,100657.3, 17 , 3 ,635.3657
Set Internal Change=Bald Eagle      ,Loc Hav         ,99452.75, 17 , 3 ,635.3617
Set Internal Change=Bald Eagle      ,Loc Hav         ,98206.87, 17 , 3 ,635.3605
Set Internal Change=Bald Eagle      ,Loc Hav         ,97607.35, 17 , 3 ,635.3531
Set Internal Change=Bald Eagle      ,Loc Hav         ,96370.43, 17 , 3 ,635.3525
Set Internal Change=Bald Eagle      ,Loc Hav         ,94560.01, 17 , 3 ,635.3502
Set Internal Change=Bald Eagle      ,Loc Hav         ,93391.71, 17 , 3 ,635.3483
Set Internal Change=Bald Eagle      ,Loc Hav         ,92011.85, 17 , 3 ,635.3464
Set Internal Change=Bald Eagle      ,Loc Hav         ,91030.01, 17 , 3 ,635.3453
Set Internal Change=Bald Eagle      ,Loc Hav         ,90096.99, 17 , 3 ,635.3454
Set Internal Change=Bald Eagle      ,Loc Hav         ,89060.69, 17 , 3 ,635.3451
Set Internal Change=Bald Eagle      ,Loc Hav         ,87861.14, 17 , 3 ,635.3452
Set Internal Change=Bald Eagle      ,Loc Hav         ,86942.04, 17 , 3 ,635.3452
Set Internal Change=Bald Eagle      ,Loc Hav         ,85569.53, 17 , 3 ,635.3453
Set Internal Change=Bald Eagle      ,Loc Hav         ,84724.08, 17 , 3 ,635.3452
Set Internal Change=Bald Eagle      ,Loc Hav         ,83563.41, 17 , 3 ,635.3452
Set Internal Change=Bald Eagle      ,Loc Hav         ,82607.89, 17 , 3 ,635.3453
Set Internal Change=Bald Eagle      ,Loc Hav         ,81849.41, 17 , 3 ,635.3449
Set Internal Change=Bald Eagle      ,Loc Hav         ,81084.18, 17 , 3 ,593.204
Set Internal Change=Bald Eagle      ,Loc Hav         ,80500.50, 17 , 3 ,591.3564
Set Internal Change=Bald Eagle      ,Loc Hav         ,79684.28, 17 , 3 ,590.379
Set Internal Change=Bald Eagle      ,Loc Hav         ,78627.87, 17 , 3 ,589.6815
Set Internal Change=Bald Eagle      ,Loc Hav         ,76643.40, 17 , 3 ,588.1872
Set Internal Change=Bald Eagle      ,Loc Hav         ,76002.96, 17 , 3 ,587.4131
Set Internal Change=Bald Eagle      ,Loc Hav         ,75917.82, 17 , 3 ,587.2416
Set Internal Change=Bald Eagle      ,Loc Hav         ,75616.14, 17 , 3 ,586.8198
Set Internal Change=Bald Eagle      ,Loc Hav         ,74650.60, 17 , 3 ,585.7446
Set Internal Change=Bald Eagle      ,Loc Hav         ,74207.96, 17 , 3 ,585.3757
Set Internal Change=Bald Eagle      ,Loc Hav         ,73504.24, 17 , 3 ,584.8638
Set Internal Change=Bald Eagle      ,Loc Hav         ,72303.68, 17 , 3 ,584.2328
Set Internal Change=Bald Eagle      ,Loc Hav         ,71400.81, 17 , 3 ,583.647
Set Internal Change=Bald Eagle      ,Loc Hav         ,70651.52, 17 , 3 ,583.0818
Set Internal Change=Bald Eagle      ,Loc Hav         ,69567.33, 17 , 3 ,582.1943
Set Internal Change=Bald Eagle      ,Loc Hav         ,68604.09, 17 , 3 ,581.5169
Set Internal Change=Bald Eagle      ,Loc Hav         ,67326.78, 17 , 3 ,580.7565
Set Internal Change=Bald Eagle      ,Loc Hav         ,66070.17, 17 , 3 ,579.6819
Set Internal Change=Bald Eagle      ,Loc Hav         ,64908.02, 17 , 3 ,578.4411
Set Internal Change=Bald Eagle      ,Loc Hav         ,63812.99, 17 , 3 ,577.0157
Set Internal Change=Bald Eagle      ,Loc Hav         ,62746.41, 17 , 3 ,576.0017
Set Internal Change=Bald Eagle      ,Loc Hav         ,61896.89, 17 , 3 ,575.3522
Set Internal Change=Bald Eagle      ,Loc Hav         ,60901.09, 17 , 3 ,574.3967
Set Internal Change=Bald Eagle      ,Loc Hav         ,59795.28, 17 , 3 ,573.395
Set Internal Change=Bald Eagle      ,Loc Hav         ,58836.23, 17 , 3 ,572.6932
Set Internal Change=Bald Eagle      ,Loc Hav         ,58708.54, 17 , 3 ,572.5984
Set Internal Change=Bald Eagle      ,Loc Hav         ,58091.91, 17 , 3 ,572.3204
Set Internal Change=Bald Eagle      ,Loc Hav         ,57700.27, 17 , 3 ,572.0296
Set Internal Change=Bald Eagle      ,Loc Hav         ,57250.60, 17 , 3 ,571.7598
Set Internal Change=Bald Eagle      ,Loc Hav         ,56775.92, 17 , 3 ,571.341
Set Internal Change=Bald Eagle      ,Loc Hav         ,56243.79, 17 , 3 ,571.0079
Set Internal Change=Bald Eagle      ,Loc Hav         ,55700.55, 17 , 3 ,570.6497
Set Internal Change=Bald Eagle      ,Loc Hav         ,54696.51, 17 , 3 ,569.9675
Set Internal Change=Bald Eagle      ,Loc Hav         ,53922.53, 17 , 3 ,569.3358
Set Internal Change=Bald Eagle      ,Loc Hav         ,52879.19, 17 , 3 ,568.6046
Set Internal Change=Bald Eagle      ,Loc Hav         ,51784.74, 17 , 3 ,567.9117
Set Internal Change=Bald Eagle      ,Loc Hav         ,50720.68, 17 , 3 ,567.3534
Set Internal Change=Bald Eagle      ,Loc Hav         ,49715.77, 17 , 3 ,567.1259
Set Internal Change=Bald Eagle      ,Loc Hav         ,48965.94, 17 , 3 ,566.9125
Set Internal Change=Bald Eagle      ,Loc Hav         ,48110.09, 17 , 3 ,566.0084
Set Internal Change=Bald Eagle      ,Loc Hav         ,47453.14, 17 , 3 ,565.1518
Set Internal Change=Bald Eagle      ,Loc Hav         ,46722.59, 17 , 3 ,564.4631
Set Internal Change=Bald Eagle      ,Loc Hav         ,46310.48, 17 , 3 ,564.2411
Set Internal Change=Bald Eagle      ,Loc Hav         ,45805.37, 17 , 3 ,563.9563
Set Internal Change=Bald Eagle      ,Loc Hav         ,45233.89, 17 , 3 ,563.6168
Set Internal Change=Bald Eagle      ,Loc Hav         ,44529.29, 17 , 3 ,563.1618
Set Internal Change=Bald Eagle      ,Loc Hav         ,43919.30, 17 , 3 ,562.8711
Set Internal Change=Bald Eagle      ,Loc Hav         ,42895.87, 17 , 3 ,562.437
Set Internal Change=Bald Eagle      ,Loc Hav         ,41806.43, 17 , 3 ,562.0006
Set Internal Change=Bald Eagle      ,Loc Hav         ,40526.85, 17 , 3 ,561.708
Set Internal Change=Bald Eagle      ,Loc Hav         ,39499.37, 17 , 3 ,561.5592
Set Internal Change=Bald Eagle      ,Loc Hav         ,38446.87, 17 , 3 ,561.2625
Set Internal Change=Bald Eagle      ,Loc Hav         ,37962.54, 17 , 3 ,561.0815
Set Internal Change=Bald Eagle      ,Loc Hav         ,37385.23, 17 , 3 ,560.8799
Set Internal Change=Bald Eagle      ,Loc Hav         ,36769.88, 17 , 3 ,560.6816
Set Internal Change=Bald Eagle      ,Loc Hav         ,36663.76, 17 , 3 ,560.5623
Set Internal Change=Bald Eagle      ,Loc Hav         ,36339.56, 17 , 3 ,560.4034
Set Internal Change=Bald Eagle      ,Loc Hav         ,35648.50, 17 , 3 ,560.0222
Set Internal Change=Bald Eagle      ,Loc Hav         ,35072.37, 17 , 3 ,559.831
Set Internal Change=Bald Eagle      ,Loc Hav         ,34098.93, 17 , 3 ,559.5738
Set Internal Change=Bald Eagle      ,Loc Hav         ,33498.68, 17 , 3 ,559.3892
Set Internal Change=Bald Eagle      ,Loc Hav         ,32195.47, 17 , 3 ,558.3098
Set Internal Change=Bald Eagle      ,Loc Hav         ,30878.12, 17 , 3 ,557.3619
Set Internal Change=Bald Eagle      ,Loc Hav         ,29563.77, 17 , 3 ,556.8047
Set Internal Change=Bald Eagle      ,Loc Hav         ,27226.40, 17 , 3 ,553.8969
Set Internal Change=Bald Eagle      ,Loc Hav         ,25960.70, 17 , 3 ,551.7754
Set Internal Change=Bald Eagle      ,Loc Hav         ,24843.25, 17 , 3 ,550.8801
Set Internal Change=Bald Eagle      ,Loc Hav         ,24417.73, 17 , 3 ,550.629
Set Internal Change=Bald Eagle      ,Loc Hav         ,23872.06, 17 , 3 ,549.7529
Set Internal Change=Bald Eagle      ,Loc Hav         ,23783.65, 17 , 3 ,549.7238
Set Internal Change=Bald Eagle      ,Loc Hav         ,23384.79, 17 , 3 ,549.5624
Set Internal Change=Bald Eagle      ,Loc Hav         ,22982.97, 17 , 3 ,549.3917
Set Internal Change=Bald Eagle      ,Loc Hav         ,22386.15, 17 , 3 ,548.9863
Set Internal Change=Bald Eagle      ,Loc Hav         ,21283.34, 17 , 3 ,548.4537
Set Internal Change=Bald Eagle      ,Loc Hav         ,21199.93, 17 , 3 ,548.4164
Set Internal Change=Bald Eagle      ,Loc Hav         ,20127.30, 17 , 3 ,547.9053
Set Internal Change=Bald Eagle      ,Loc Hav         ,19036.24, 17 , 3 ,546.7773
Set Internal Change=Bald Eagle      ,Loc Hav         ,18200.10, 17 , 3 ,546.2886
Set Internal Change=Bald Eagle      ,Loc Hav         ,17549.23, 17 , 3 ,546.157
Set Internal Change=Bald Eagle      ,Loc Hav         ,16787.45, 17 , 3 ,545.9613
Set Internal Change=Bald Eagle      ,Loc Hav         ,15407.88, 17 , 3 ,545.3937
Set Internal Change=Bald Eagle      ,Loc Hav         ,14814.34, 17 , 3 ,544.9425
Set Internal Change=Bald Eagle      ,Loc Hav         ,13326.74, 17 , 3 ,544.3495
Set Internal Change=Bald Eagle      ,Loc Hav         ,12035.22, 17 , 3 ,544.0077
Set Internal Change=Bald Eagle      ,Loc Hav         ,11865.80, 17 , 3 ,543.9662
Set Internal Change=Bald Eagle      ,Loc Hav         ,11116.44, 17 , 3 ,543.6232
Set Internal Change=Bald Eagle      ,Loc Hav         ,10995.73, 17 , 3 ,543.5725
Set Internal Change=Bald Eagle      ,Loc Hav         ,10221.14, 17 , 3 ,543.1851
Set Internal Change=Bald Eagle      ,Loc Hav         ,9258.941, 17 , 3 ,542.8654
Set Internal Change=Bald Eagle      ,Loc Hav         ,8541.462, 17 , 3 ,542.7432
Set Internal Change=Bald Eagle      ,Loc Hav         ,7936.130, 17 , 3 ,542.6091
Set Internal Change=Bald Eagle      ,Loc Hav         ,6940.066, 17 , 3 ,542.3128
Set Internal Change=Bald Eagle      ,Loc Hav         ,6267.489, 17 , 3 ,542.1447
Set Internal Change=Bald Eagle      ,Loc Hav         ,5523.234, 17 , 3 ,541.9775
Set Internal Change=Bald Eagle      ,Loc Hav         ,4293.710, 17 , 3 ,541.6913
Set Internal Change=Bald Eagle      ,Loc Hav         ,3047.378, 17 , 3 ,541.4093
Set Internal Change=Bald Eagle      ,Loc Hav         ,2731.142, 17 , 3 ,541.2969
Set Internal Change=Bald Eagle      ,Loc Hav         ,2501.017, 17 , 3 ,541.2966
Set Internal Change=Bald Eagle      ,Loc Hav         ,2371.827, 17 , 3 ,541.2797
Set Internal Change=Bald Eagle      ,Loc Hav         ,1692.633, 17 , 3 ,541.2299
Set Internal Change=Bald Eagle      ,Loc Hav         ,1212.855, 17 , 3 ,541.1932
Set Internal Change=Bald Eagle      ,Loc Hav         ,659.942 , 17 , 3 ,541.1544
Set Internal Change=Bald Eagle      ,Loc Hav         ,138154.4, 18 , 3 ,671.4462
Set Internal Change=Bald Eagle      ,Loc Hav         ,137690.8, 18 , 3 ,671.2567
Set Internal Change=Bald Eagle      ,Loc Hav         ,137327.0, 18 , 3 ,670.799
Set Internal Change=Bald Eagle      ,Loc Hav         ,136564.9, 18 , 3 ,667.5024
Set Internal Change=Bald Eagle      ,Loc Hav         ,136202.3, 18 , 3 ,667.0104
Set Internal Change=Bald Eagle      ,Loc Hav         ,135591.4, 18 , 3 ,665.3304
Set Internal Change=Bald Eagle      ,Loc Hav         ,135068.7, 18 , 3 ,664.7833
Set Internal Change=Bald Eagle      ,Loc Hav         ,134487.2, 18 , 3 ,663.7427
Set Internal Change=Bald Eagle      ,Loc Hav         ,133881.0, 18 , 3 ,663.009
Set Internal Change=Bald Eagle      ,Loc Hav         ,133446.1, 18 , 3 ,662.3889
Set Internal Change=Bald Eagle      ,Loc Hav         ,132973.6, 18 , 3 ,661.7827
Set Internal Change=Bald Eagle      ,Loc Hav         ,132363.8, 18 , 3 ,660.2575
Set Internal Change=Bald Eagle      ,Loc Hav         ,131699.7, 18 , 3 ,658.061
Set Internal Change=Bald Eagle      ,Loc Hav         ,130997.6, 18 , 3 ,656.0173
Set Internal Change=Bald Eagle      ,Loc Hav         ,130339.2, 18 , 3 ,654.485
Set Internal Change=Bald Eagle      ,Loc Hav         ,129627.5, 18 , 3 ,652.9982
Set Internal Change=Bald Eagle      ,Loc Hav         ,128760.7, 18 , 3 ,651.6766
Set Internal Change=Bald Eagle      ,Loc Hav         ,128280.7, 18 , 3 ,651.2362
Set Internal Change=Bald Eagle      ,Loc Hav         ,127410.9, 18 , 3 ,650.6096
Set Internal Change=Bald Eagle      ,Loc Hav         ,126741.0, 18 , 3 ,649.8963
Set Internal Change=Bald Eagle      ,Loc Hav         ,126454.1, 18 , 3 ,649.2014
Set Internal Change=Bald Eagle      ,Loc Hav         ,126062.6, 18 , 3 ,648.443
Set Internal Change=Bald Eagle      ,Loc Hav         ,125704.7, 18 , 3 ,647.8683
Set Internal Change=Bald Eagle      ,Loc Hav         ,125091.9, 18 , 3 ,646.9434
Set Internal Change=Bald Eagle      ,Loc Hav         ,124615.5, 18 , 3 ,646.4805
Set Internal Change=Bald Eagle      ,Loc Hav         ,124025.0, 18 , 3 ,645.281
Set Internal Change=Bald Eagle      ,Loc Hav         ,123503.5, 18 , 3 ,644.4149
Set Internal Change=Bald Eagle      ,Loc Hav         ,123123.6, 18 , 3 ,643.9247
Set Internal Change=Bald Eagle      ,Loc Hav         ,122703.3, 18 , 3 ,643.4811
Set Internal Change=Bald Eagle      ,Loc Hav         ,122190.8, 18 , 3 ,642.9259
Set Internal Change=Bald Eagle      ,Loc Hav         ,121754.0, 18 , 3 ,642.5161
Set Internal Change=Bald Eagle      ,Loc Hav         ,121394.1, 18 , 3 ,642.2275
Set Internal Change=Bald Eagle      ,Loc Hav         ,120862.6, 18 , 3 ,641.7739
Set Internal Change=Bald Eagle      ,Loc Hav         ,120421.4, 18 , 3 ,641.1754
Set Internal Change=Bald Eagle      ,Loc Hav         ,119954.9, 18 , 3 ,640.6301
Set Internal Change=Bald Eagle      ,Loc Hav         ,119473.8, 18 , 3 ,640.0501
Set Internal Change=Bald Eagle      ,Loc Hav         ,118901.0, 18 , 3 ,639.4329
Set Internal Change=Bald Eagle      ,Loc Hav         ,118300.5, 18 , 3 ,639.0441
Set Internal Change=Bald Eagle      ,Loc Hav         ,117753.9, 18 , 3 ,638.8672
Set Internal Change=Bald Eagle      ,Loc Hav         ,117180.8, 18 , 3 ,638.7502
Set Internal Change=Bald Eagle      ,Loc Hav         ,116401.3, 18 , 3 ,638.6658
Set Internal Change=Bald Eagle      ,Loc Hav         ,115584.2, 18 , 3 ,638.5807
Set Internal Change=Bald Eagle      ,Loc Hav         ,114899.8, 18 , 3 ,638.5128
Set Internal Change=Bald Eagle      ,Loc Hav         ,113985.6, 18 , 3 ,638.4286
Set Internal Change=Bald Eagle      ,Loc Hav         ,112856.9, 18 , 3 ,638.3571
Set Internal Change=Bald Eagle      ,Loc Hav         ,111971.0, 18 , 3 ,638.3248
Set Internal Change=Bald Eagle      ,Loc Hav         ,110657.4, 18 , 3 ,638.2789
Set Internal Change=Bald Eagle      ,Loc Hav         ,109659.9, 18 , 3 ,638.2416
Set Internal Change=Bald Eagle      ,Loc Hav         ,108600.1, 18 , 3 ,638.2099
Set Internal Change=Bald Eagle      ,Loc Hav         ,107333.6, 18 , 3 ,638.1782
Set Internal Change=Bald Eagle      ,Loc Hav         ,106466.0, 18 , 3 ,638.1634
Set Internal Change=Bald Eagle      ,Loc Hav         ,105178.6, 18 , 3 ,638.1499
Set Internal Change=Bald Eagle      ,Loc Hav         ,104647.2, 18 , 3 ,638.1378
Set Internal Change=Bald Eagle      ,Loc Hav         ,104195.0, 18 , 3 ,638.1335
Set Internal Change=Bald Eagle      ,Loc Hav         ,103854.0, 18 , 3 ,638.1298
Set Internal Change=Bald Eagle      ,Loc Hav         ,103369.7, 18 , 3 ,638.1198
Set Internal Change=Bald Eagle      ,Loc Hav         ,103122.3, 18 , 3 ,638.0475
Set Internal Change=Bald Eagle      ,Loc Hav         ,101440.3, 18 , 3 ,638.0358
Set Internal Change=Bald Eagle      ,Loc Hav         ,100657.3, 18 , 3 ,638.0328
Set Internal Change=Bald Eagle      ,Loc Hav         ,99452.75, 18 , 3 ,638.03
Set Internal Change=Bald Eagle      ,Loc Hav         ,98206.87, 18 , 3 ,638.0294
Set Internal Change=Bald Eagle      ,Loc Hav         ,97607.35, 18 , 3 ,638.0237
Set Internal Change=Bald Eagle      ,Loc Hav         ,96370.43, 18 , 3 ,638.0238
Set Internal Change=Bald Eagle      ,Loc Hav         ,94560.01, 18 , 3 ,638.022
Set Internal Change=Bald Eagle      ,Loc Hav         ,93391.71, 18 , 3 ,638.0204
Set Internal Change=Bald Eagle      ,Loc Hav         ,92011.85, 18 , 3 ,638.0189
Set Internal Change=Bald Eagle      ,Loc Hav         ,91030.01, 18 , 3 ,638.0179
Set Internal Change=Bald Eagle      ,Loc Hav         ,90096.99, 18 , 3 ,638.0181
Set Internal Change=Bald Eagle      ,Loc Hav         ,89060.69, 18 , 3 ,638.0179
Set Internal Change=Bald Eagle      ,Loc Hav         ,87861.14, 18 , 3 ,638.0179
Set Internal Change=Bald Eagle      ,Loc Hav         ,86942.04, 18 , 3 ,638.0178
Set Internal Change=Bald Eagle      ,Loc Hav         ,85569.53, 18 , 3 ,638.0178
Set Internal Change=Bald Eagle      ,Loc Hav         ,84724.08, 18 , 3 ,638.0178
Set Internal Change=Bald Eagle      ,Loc Hav         ,83563.41, 18 , 3 ,638.0178
Set Internal Change=Bald Eagle      ,Loc Hav         ,82607.89, 18 , 3 ,638.0178
Set Internal Change=Bald Eagle      ,Loc Hav         ,81849.41, 18 , 3 ,638.0175
Set Internal Change=Bald Eagle      ,Loc Hav         ,81084.18, 18 , 3 ,593.4529
Set Internal Change=Bald Eagle      ,Loc Hav         ,80500.50, 18 , 3 ,591.5311
Set Internal Change=Bald Eagle      ,Loc Hav         ,79684.28, 18 , 3 ,590.5291
Set Internal Change=Bald Eagle      ,Loc Hav         ,78627.87, 18 , 3 ,589.7859
Set Internal Change=Bald Eagle      ,Loc Hav         ,76643.40, 18 , 3 ,588.3524
Set Internal Change=Bald Eagle      ,Loc Hav         ,76002.96, 18 , 3 ,587.5701
Set Internal Change=Bald Eagle      ,Loc Hav         ,75917.82, 18 , 3 ,587.3873
Set Internal Change=Bald Eagle      ,Loc Hav         ,75616.14, 18 , 3 ,586.9903
Set Internal Change=Bald Eagle      ,Loc Hav         ,74650.60, 18 , 3 ,585.9079
Set Internal Change=Bald Eagle      ,Loc Hav         ,74207.96, 18 , 3 ,585.5439
Set Internal Change=Bald Eagle      ,Loc Hav         ,73504.24, 18 , 3 ,585.0469
Set Internal Change=Bald Eagle      ,Loc Hav         ,72303.68, 18 , 3 ,584.4357
Set Internal Change=Bald Eagle      ,Loc Hav         ,71400.81, 18 , 3 ,583.8583
Set Internal Change=Bald Eagle      ,Loc Hav         ,70651.52, 18 , 3 ,583.2814
Set Internal Change=Bald Eagle      ,Loc Hav         ,69567.33, 18 , 3 ,582.389
Set Internal Change=Bald Eagle      ,Loc Hav         ,68604.09, 18 , 3 ,581.7324
Set Internal Change=Bald Eagle      ,Loc Hav         ,67326.78, 18 , 3 ,580.9849
Set Internal Change=Bald Eagle      ,Loc Hav         ,66070.17, 18 , 3 ,579.9004
Set Internal Change=Bald Eagle      ,Loc Hav         ,64908.02, 18 , 3 ,578.7147
Set Internal Change=Bald Eagle      ,Loc Hav         ,63812.99, 18 , 3 ,577.2853
Set Internal Change=Bald Eagle      ,Loc Hav         ,62746.41, 18 , 3 ,576.2747
Set Internal Change=Bald Eagle      ,Loc Hav         ,61896.89, 18 , 3 ,575.6374
Set Internal Change=Bald Eagle      ,Loc Hav         ,60901.09, 18 , 3 ,574.6816
Set Internal Change=Bald Eagle      ,Loc Hav         ,59795.28, 18 , 3 ,573.6898
Set Internal Change=Bald Eagle      ,Loc Hav         ,58836.23, 18 , 3 ,572.9647
Set Internal Change=Bald Eagle      ,Loc Hav         ,58708.54, 18 , 3 ,572.8657
Set Internal Change=Bald Eagle      ,Loc Hav         ,58091.91, 18 , 3 ,572.5969
Set Internal Change=Bald Eagle      ,Loc Hav         ,57700.27, 18 , 3 ,572.3064
Set Internal Change=Bald Eagle      ,Loc Hav         ,57250.60, 18 , 3 ,572.0313
Set Internal Change=Bald Eagle      ,Loc Hav         ,56775.92, 18 , 3 ,571.6121
Set Internal Change=Bald Eagle      ,Loc Hav         ,56243.79, 18 , 3 ,571.2729
Set Internal Change=Bald Eagle      ,Loc Hav         ,55700.55, 18 , 3 ,570.9238
Set Internal Change=Bald Eagle      ,Loc Hav         ,54696.51, 18 , 3 ,570.246
Set Internal Change=Bald Eagle      ,Loc Hav         ,53922.53, 18 , 3 ,569.6008
Set Internal Change=Bald Eagle      ,Loc Hav         ,52879.19, 18 , 3 ,568.858
Set Internal Change=Bald Eagle      ,Loc Hav         ,51784.74, 18 , 3 ,568.1542
Set Internal Change=Bald Eagle      ,Loc Hav         ,50720.68, 18 , 3 ,567.5759
Set Internal Change=Bald Eagle      ,Loc Hav         ,49715.77, 18 , 3 ,567.3474
Set Internal Change=Bald Eagle      ,Loc Hav         ,48965.94, 18 , 3 ,567.1328
Set Internal Change=Bald Eagle      ,Loc Hav         ,48110.09, 18 , 3 ,566.2782
Set Internal Change=Bald Eagle      ,Loc Hav         ,47453.14, 18 , 3 ,565.4166
Set Internal Change=Bald Eagle      ,Loc Hav         ,46722.59, 18 , 3 ,564.7159
Set Internal Change=Bald Eagle      ,Loc Hav         ,46310.48, 18 , 3 ,564.496
Set Internal Change=Bald Eagle      ,Loc Hav         ,45805.37, 18 , 3 ,564.2064
Set Internal Change=Bald Eagle      ,Loc Hav         ,45233.89, 18 , 3 ,563.8564
Set Internal Change=Bald Eagle      ,Loc Hav         ,44529.29, 18 , 3 ,563.392
Set Internal Change=Bald Eagle      ,Loc Hav         ,43919.30, 18 , 3 ,563.0956
Set Internal Change=Bald Eagle      ,Loc Hav         ,42895.87, 18 , 3 ,562.6727
Set Internal Change=Bald Eagle      ,Loc Hav         ,41806.43, 18 , 3 ,562.2627
Set Internal Change=Bald Eagle      ,Loc Hav         ,40526.85, 18 , 3 ,561.9935
Set Internal Change=Bald Eagle      ,Loc Hav         ,39499.37, 18 , 3 ,561.8491
Set Internal Change=Bald Eagle      ,Loc Hav         ,38446.87, 18 , 3 ,561.5507
Set Internal Change=Bald Eagle      ,Loc Hav         ,37962.54, 18 , 3 ,561.3681
Set Internal Change=Bald Eagle      ,Loc Hav         ,37385.23, 18 , 3 ,561.1594
Set Internal Change=Bald Eagle      ,Loc Hav         ,36769.88, 18 , 3 ,560.9424
Set Internal Change=Bald Eagle      ,Loc Hav         ,36663.76, 18 , 3 ,560.8114
Set Internal Change=Bald Eagle      ,Loc Hav         ,36339.56, 18 , 3 ,560.6492
Set Internal Change=Bald Eagle      ,Loc Hav         ,35648.50, 18 , 3 ,560.2411
Set Internal Change=Bald Eagle      ,Loc Hav         ,35072.37, 18 , 3 ,560.0354
Set Internal Change=Bald Eagle      ,Loc Hav         ,34098.93, 18 , 3 ,559.7585
Set Internal Change=Bald Eagle      ,Loc Hav         ,33498.68, 18 , 3 ,559.5592
Set Internal Change=Bald Eagle      ,Loc Hav         ,32195.47, 18 , 3 ,558.563
Set Internal Change=Bald Eagle      ,Loc Hav         ,30878.12, 18 , 3 ,557.6878
Set Internal Change=Bald Eagle      ,Loc Hav         ,29563.77, 18 , 3 ,557.1349
Set Internal Change=Bald Eagle      ,Loc Hav         ,27226.40, 18 , 3 ,554.1533
Set Internal Change=Bald Eagle      ,Loc Hav         ,25960.70, 18 , 3 ,552.0568
Set Internal Change=Bald Eagle      ,Loc Hav         ,24843.25, 18 , 3 ,551.2223
Set Internal Change=Bald Eagle      ,Loc Hav         ,24417.73, 18 , 3 ,550.9596
Set Internal Change=Bald Eagle      ,Loc Hav         ,23872.06, 18 , 3 ,550.0898
Set Internal Change=Bald Eagle      ,Loc Hav         ,23783.65, 18 , 3 ,550.0598
Set Internal Change=Bald Eagle      ,Loc Hav         ,23384.79, 18 , 3 ,549.9145
Set Internal Change=Bald Eagle      ,Loc Hav         ,22982.97, 18 , 3 ,549.7538
Set Internal Change=Bald Eagle      ,Loc Hav         ,22386.15, 18 , 3 ,549.3684
Set Internal Change=Bald Eagle      ,Loc Hav         ,21283.34, 18 , 3 ,548.8423
Set Internal Change=Bald Eagle      ,Loc Hav         ,21199.93, 18 , 3 ,548.7991
Set Internal Change=Bald Eagle      ,Loc Hav         ,20127.30, 18 , 3 ,548.2838
Set Internal Change=Bald Eagle      ,Loc Hav         ,19036.24, 18 , 3 ,547.2
Set Internal Change=Bald Eagle      ,Loc Hav         ,18200.10, 18 , 3 ,546.7506
Set Internal Change=Bald Eagle      ,Loc Hav         ,17549.23, 18 , 3 ,546.6226
Set Internal Change=Bald Eagle      ,Loc Hav         ,16787.45, 18 , 3 ,546.424
Set Internal Change=Bald Eagle      ,Loc Hav         ,15407.88, 18 , 3 ,545.8506
Set Internal Change=Bald Eagle      ,Loc Hav         ,14814.34, 18 , 3 ,545.374
Set Internal Change=Bald Eagle      ,Loc Hav         ,13326.74, 18 , 3 ,544.7864
Set Internal Change=Bald Eagle      ,Loc Hav         ,12035.22, 18 , 3 ,544.4441
Set Internal Change=Bald Eagle      ,Loc Hav         ,11865.80, 18 , 3 ,544.4025
Set Internal Change=Bald Eagle      ,Loc Hav         ,11116.44, 18 , 3 ,544.0715
Set Internal Change=Bald Eagle      ,Loc Hav         ,10995.73, 18 , 3 ,544.0237
Set Internal Change=Bald Eagle      ,Loc Hav         ,10221.14, 18 , 3 ,543.6547
Set Internal Change=Bald Eagle      ,Loc Hav         ,9258.941, 18 , 3 ,543.3453
Set Internal Change=Bald Eagle      ,Loc Hav         ,8541.462, 18 , 3 ,543.2247
Set Internal Change=Bald Eagle      ,Loc Hav         ,7936.130, 18 , 3 ,543.0929
Set Internal Change=Bald Eagle      ,Loc Hav         ,6940.066, 18 , 3 ,542.7965
Set Internal Change=Bald Eagle      ,Loc Hav         ,6267.489, 18 , 3 ,542.634
Set Internal Change=Bald Eagle      ,Loc Hav         ,5523.234, 18 , 3 ,542.4625
Set Internal Change=Bald Eagle      ,Loc Hav         ,4293.710, 18 , 3 ,542.1746
Set Internal Change=Bald Eagle      ,Loc Hav         ,3047.378, 18 , 3 ,541.8942
Set Internal Change=Bald Eagle      ,Loc Hav         ,2731.142, 18 , 3 ,541.7809
Set Internal Change=Bald Eagle      ,Loc Hav         ,2501.017, 18 , 3 ,541.7825
Set Internal Change=Bald Eagle      ,Loc Hav         ,2371.827, 18 , 3 ,541.7651
Set Internal Change=Bald Eagle      ,Loc Hav         ,1692.633, 18 , 3 ,541.7137
Set Internal Change=Bald Eagle      ,Loc Hav         ,1212.855, 18 , 3 ,541.6757
Set Internal Change=Bald Eagle      ,Loc Hav         ,659.942 , 18 , 3 ,541.6388
Set Internal Change=Bald Eagle      ,Loc Hav         ,138154.4, 19 , 3 ,671.827
Set Internal Change=Bald Eagle      ,Loc Hav         ,137690.8, 19 , 3 ,671.6639
Set Internal Change=Bald Eagle      ,Loc Hav         ,137327.0, 19 , 3 ,671.204
Set Internal Change=Bald Eagle      ,Loc Hav         ,136564.9, 19 , 3 ,667.8557
Set Internal Change=Bald Eagle      ,Loc Hav         ,136202.3, 19 , 3 ,667.3707
Set Internal Change=Bald Eagle      ,Loc Hav         ,135591.4, 19 , 3 ,665.6521
Set Internal Change=Bald Eagle      ,Loc Hav         ,135068.7, 19 , 3 ,665.1259
Set Internal Change=Bald Eagle      ,Loc Hav         ,134487.2, 19 , 3 ,664.0822
Set Internal Change=Bald Eagle      ,Loc Hav         ,133881.0, 19 , 3 ,663.3456
Set Internal Change=Bald Eagle      ,Loc Hav         ,133446.1, 19 , 3 ,662.712
Set Internal Change=Bald Eagle      ,Loc Hav         ,132973.6, 19 , 3 ,662.1007
Set Internal Change=Bald Eagle      ,Loc Hav         ,132363.8, 19 , 3 ,660.5526
Set Internal Change=Bald Eagle      ,Loc Hav         ,131699.7, 19 , 3 ,658.3258
Set Internal Change=Bald Eagle      ,Loc Hav         ,130997.6, 19 , 3 ,656.2759
Set Internal Change=Bald Eagle      ,Loc Hav         ,130339.2, 19 , 3 ,654.7639
Set Internal Change=Bald Eagle      ,Loc Hav         ,129627.5, 19 , 3 ,653.3088
Set Internal Change=Bald Eagle      ,Loc Hav         ,128760.7, 19 , 3 ,652.0379
Set Internal Change=Bald Eagle      ,Loc Hav         ,128280.7, 19 , 3 ,651.6198
Set Internal Change=Bald Eagle      ,Loc Hav         ,127410.9, 19 , 3 ,651.0098
Set Internal Change=Bald Eagle      ,Loc Hav         ,126741.0, 19 , 3 ,650.3154
Set Internal Change=Bald Eagle      ,Loc Hav         ,126454.1, 19 , 3 ,649.6218
Set Internal Change=Bald Eagle      ,Loc Hav         ,126062.6, 19 , 3 ,648.8845
Set Internal Change=Bald Eagle      ,Loc Hav         ,125704.7, 19 , 3 ,648.3336
Set Internal Change=Bald Eagle      ,Loc Hav         ,125091.9, 19 , 3 ,647.4481
Set Internal Change=Bald Eagle      ,Loc Hav         ,124615.5, 19 , 3 ,647.0126
Set Internal Change=Bald Eagle      ,Loc Hav         ,124025.0, 19 , 3 ,645.9308
Set Internal Change=Bald Eagle      ,Loc Hav         ,123503.5, 19 , 3 ,645.1992
Set Internal Change=Bald Eagle      ,Loc Hav         ,123123.6, 19 , 3 ,644.7941
Set Internal Change=Bald Eagle      ,Loc Hav         ,122703.3, 19 , 3 ,644.4286
Set Internal Change=Bald Eagle      ,Loc Hav         ,122190.8, 19 , 3 ,643.9855
Set Internal Change=Bald Eagle      ,Loc Hav         ,121754.0, 19 , 3 ,643.6658
Set Internal Change=Bald Eagle      ,Loc Hav         ,121394.1, 19 , 3 ,643.442
Set Internal Change=Bald Eagle      ,Loc Hav         ,120862.6, 19 , 3 ,643.1015
Set Internal Change=Bald Eagle      ,Loc Hav         ,120421.4, 19 , 3 ,642.6594
Set Internal Change=Bald Eagle      ,Loc Hav         ,119954.9, 19 , 3 ,642.272
Set Internal Change=Bald Eagle      ,Loc Hav         ,119473.8, 19 , 3 ,641.9017
Set Internal Change=Bald Eagle      ,Loc Hav         ,118901.0, 19 , 3 ,641.5423
Set Internal Change=Bald Eagle      ,Loc Hav         ,118300.5, 19 , 3 ,641.3085
Set Internal Change=Bald Eagle      ,Loc Hav         ,117753.9, 19 , 3 ,641.2042
Set Internal Change=Bald Eagle      ,Loc Hav         ,117180.8, 19 , 3 ,641.1451
Set Internal Change=Bald Eagle      ,Loc Hav         ,116401.3, 19 , 3 ,641.1027
Set Internal Change=Bald Eagle      ,Loc Hav         ,115584.2, 19 , 3 ,641.0498
Set Internal Change=Bald Eagle      ,Loc Hav         ,114899.8, 19 , 3 ,641.0085
Set Internal Change=Bald Eagle      ,Loc Hav         ,113985.6, 19 , 3 ,640.9514
Set Internal Change=Bald Eagle      ,Loc Hav         ,112856.9, 19 , 3 ,640.9055
Set Internal Change=Bald Eagle      ,Loc Hav         ,111971.0, 19 , 3 ,640.886
Set Internal Change=Bald Eagle      ,Loc Hav         ,110657.4, 19 , 3 ,640.8559
Set Internal Change=Bald Eagle      ,Loc Hav         ,109659.9, 19 , 3 ,640.8299
Set Internal Change=Bald Eagle      ,Loc Hav         ,108600.1, 19 , 3 ,640.808
Set Internal Change=Bald Eagle      ,Loc Hav         ,107333.6, 19 , 3 ,640.7857
Set Internal Change=Bald Eagle      ,Loc Hav         ,106466.0, 19 , 3 ,640.7751
Set Internal Change=Bald Eagle      ,Loc Hav         ,105178.6, 19 , 3 ,640.7655
Set Internal Change=Bald Eagle      ,Loc Hav         ,104647.2, 19 , 3 ,640.7565
Set Internal Change=Bald Eagle      ,Loc Hav         ,104195.0, 19 , 3 ,640.7532
Set Internal Change=Bald Eagle      ,Loc Hav         ,103854.0, 19 , 3 ,640.7503
Set Internal Change=Bald Eagle      ,Loc Hav         ,103369.7, 19 , 3 ,640.7433
Set Internal Change=Bald Eagle      ,Loc Hav         ,103122.3, 19 , 3 ,640.6839
Set Internal Change=Bald Eagle      ,Loc Hav         ,101440.3, 19 , 3 ,640.6752
Set Internal Change=Bald Eagle      ,Loc Hav         ,100657.3, 19 , 3 ,640.6734
Set Internal Change=Bald Eagle      ,Loc Hav         ,99452.75, 19 , 3 ,640.6712
Set Internal Change=Bald Eagle      ,Loc Hav         ,98206.87, 19 , 3 ,640.6707
Set Internal Change=Bald Eagle      ,Loc Hav         ,97607.35, 19 , 3 ,640.6661
Set Internal Change=Bald Eagle      ,Loc Hav         ,96370.43, 19 , 3 ,640.6666
Set Internal Change=Bald Eagle      ,Loc Hav         ,94560.01, 19 , 3 ,640.6652
Set Internal Change=Bald Eagle      ,Loc Hav         ,93391.71, 19 , 3 ,640.6638
Set Internal Change=Bald Eagle      ,Loc Hav         ,92011.85, 19 , 3 ,640.6625
Set Internal Change=Bald Eagle      ,Loc Hav         ,91030.01, 19 , 3 ,640.6617
Set Internal Change=Bald Eagle      ,Loc Hav         ,90096.99, 19 , 3 ,640.662
Set Internal Change=Bald Eagle      ,Loc Hav         ,89060.69, 19 , 3 ,640.6618
Set Internal Change=Bald Eagle      ,Loc Hav         ,87861.14, 19 , 3 ,640.6619
Set Internal Change=Bald Eagle      ,Loc Hav         ,86942.04, 19 , 3 ,640.6619
Set Internal Change=Bald Eagle      ,Loc Hav         ,85569.53, 19 , 3 ,640.6619
Set Internal Change=Bald Eagle      ,Loc Hav         ,84724.08, 19 , 3 ,640.6619
Set Internal Change=Bald Eagle      ,Loc Hav         ,83563.41, 19 , 3 ,640.6619
Set Internal Change=Bald Eagle      ,Loc Hav         ,82607.89, 19 , 3 ,640.6619
Set Internal Change=Bald Eagle      ,Loc Hav         ,81849.41, 19 , 3 ,640.6616
Set Internal Change=Bald Eagle      ,Loc Hav         ,81084.18, 19 , 3 ,593.7051
Set Internal Change=Bald Eagle      ,Loc Hav         ,80500.50, 19 , 3 ,591.7125
Set Internal Change=Bald Eagle      ,Loc Hav         ,79684.28, 19 , 3 ,590.6893
Set Internal Change=Bald Eagle      ,Loc Hav         ,78627.87, 19 , 3 ,589.9067
Set Internal Change=Bald Eagle      ,Loc Hav         ,76643.40, 19 , 3 ,588.5224
Set Internal Change=Bald Eagle      ,Loc Hav         ,76002.96, 19 , 3 ,587.7305
Set Internal Change=Bald Eagle      ,Loc Hav         ,75917.82, 19 , 3 ,587.5366
Set Internal Change=Bald Eagle      ,Loc Hav         ,75616.14, 19 , 3 ,587.1615
Set Internal Change=Bald Eagle      ,Loc Hav         ,74650.60, 19 , 3 ,586.0725
Set Internal Change=Bald Eagle      ,Loc Hav         ,74207.96, 19 , 3 ,585.7125
Set Internal Change=Bald Eagle      ,Loc Hav         ,73504.24, 19 , 3 ,585.2271
Set Internal Change=Bald Eagle      ,Loc Hav         ,72303.68, 19 , 3 ,584.63
Set Internal Change=Bald Eagle      ,Loc Hav         ,71400.81, 19 , 3 ,584.0569
Set Internal Change=Bald Eagle      ,Loc Hav         ,70651.52, 19 , 3 ,583.4705
Set Internal Change=Bald Eagle      ,Loc Hav         ,69567.33, 19 , 3 ,582.5792
Set Internal Change=Bald Eagle      ,Loc Hav         ,68604.09, 19 , 3 ,581.9415
Set Internal Change=Bald Eagle      ,Loc Hav         ,67326.78, 19 , 3 ,581.2108
Set Internal Change=Bald Eagle      ,Loc Hav         ,66070.17, 19 , 3 ,580.1282
Set Internal Change=Bald Eagle      ,Loc Hav         ,64908.02, 19 , 3 ,578.9867
Set Internal Change=Bald Eagle      ,Loc Hav         ,63812.99, 19 , 3 ,577.549
Set Internal Change=Bald Eagle      ,Loc Hav         ,62746.41, 19 , 3 ,576.5314
Set Internal Change=Bald Eagle      ,Loc Hav         ,61896.89, 19 , 3 ,575.8929
Set Internal Change=Bald Eagle      ,Loc Hav         ,60901.09, 19 , 3 ,574.9632
Set Internal Change=Bald Eagle      ,Loc Hav         ,59795.28, 19 , 3 ,573.9822
Set Internal Change=Bald Eagle      ,Loc Hav         ,58836.23, 19 , 3 ,573.2374
Set Internal Change=Bald Eagle      ,Loc Hav         ,58708.54, 19 , 3 ,573.1343
Set Internal Change=Bald Eagle      ,Loc Hav         ,58091.91, 19 , 3 ,572.874
Set Internal Change=Bald Eagle      ,Loc Hav         ,57700.27, 19 , 3 ,572.5835
Set Internal Change=Bald Eagle      ,Loc Hav         ,57250.60, 19 , 3 ,572.3038
Set Internal Change=Bald Eagle      ,Loc Hav         ,56775.92, 19 , 3 ,571.8833
Set Internal Change=Bald Eagle      ,Loc Hav         ,56243.79, 19 , 3 ,571.5384
Set Internal Change=Bald Eagle      ,Loc Hav         ,55700.55, 19 , 3 ,571.1959
Set Internal Change=Bald Eagle      ,Loc Hav         ,54696.51, 19 , 3 ,570.5181
Set Internal Change=Bald Eagle      ,Loc Hav         ,53922.53, 19 , 3 ,569.8561
Set Internal Change=Bald Eagle      ,Loc Hav         ,52879.19, 19 , 3 ,569.0953
Set Internal Change=Bald Eagle      ,Loc Hav         ,51784.74, 19 , 3 ,568.369
Set Internal Change=Bald Eagle      ,Loc Hav         ,50720.68, 19 , 3 ,567.7722
Set Internal Change=Bald Eagle      ,Loc Hav         ,49715.77, 19 , 3 ,567.5467
Set Internal Change=Bald Eagle      ,Loc Hav         ,48965.94, 19 , 3 ,567.3447
Set Internal Change=Bald Eagle      ,Loc Hav         ,48110.09, 19 , 3 ,566.5131
Set Internal Change=Bald Eagle      ,Loc Hav         ,47453.14, 19 , 3 ,565.6857
Set Internal Change=Bald Eagle      ,Loc Hav         ,46722.59, 19 , 3 ,564.9449
Set Internal Change=Bald Eagle      ,Loc Hav         ,46310.48, 19 , 3 ,564.7198
Set Internal Change=Bald Eagle      ,Loc Hav         ,45805.37, 19 , 3 ,564.4223
Set Internal Change=Bald Eagle      ,Loc Hav         ,45233.89, 19 , 3 ,564.0831
Set Internal Change=Bald Eagle      ,Loc Hav         ,44529.29, 19 , 3 ,563.6151
Set Internal Change=Bald Eagle      ,Loc Hav         ,43919.30, 19 , 3 ,563.31
Set Internal Change=Bald Eagle      ,Loc Hav         ,42895.87, 19 , 3 ,562.8895
Set Internal Change=Bald Eagle      ,Loc Hav         ,41806.43, 19 , 3 ,562.4991
Set Internal Change=Bald Eagle      ,Loc Hav         ,40526.85, 19 , 3 ,562.2496
Set Internal Change=Bald Eagle      ,Loc Hav         ,39499.37, 19 , 3 ,562.106
Set Internal Change=Bald Eagle      ,Loc Hav         ,38446.87, 19 , 3 ,561.7999
Set Internal Change=Bald Eagle      ,Loc Hav         ,37962.54, 19 , 3 ,561.6119
Set Internal Change=Bald Eagle      ,Loc Hav         ,37385.23, 19 , 3 ,561.3947
Set Internal Change=Bald Eagle      ,Loc Hav         ,36769.88, 19 , 3 ,561.1595
Set Internal Change=Bald Eagle      ,Loc Hav         ,36663.76, 19 , 3 ,561.0165
Set Internal Change=Bald Eagle      ,Loc Hav         ,36339.56, 19 , 3 ,560.8702
Set Internal Change=Bald Eagle      ,Loc Hav         ,35648.50, 19 , 3 ,560.4626
Set Internal Change=Bald Eagle      ,Loc Hav         ,35072.37, 19 , 3 ,560.2443
Set Internal Change=Bald Eagle      ,Loc Hav         ,34098.93, 19 , 3 ,559.9507
Set Internal Change=Bald Eagle      ,Loc Hav         ,33498.68, 19 , 3 ,559.7392
Set Internal Change=Bald Eagle      ,Loc Hav         ,32195.47, 19 , 3 ,558.7623
Set Internal Change=Bald Eagle      ,Loc Hav         ,30878.12, 19 , 3 ,557.9238
Set Internal Change=Bald Eagle      ,Loc Hav         ,29563.77, 19 , 3 ,557.3932
Set Internal Change=Bald Eagle      ,Loc Hav         ,27226.40, 19 , 3 ,554.3763
Set Internal Change=Bald Eagle      ,Loc Hav         ,25960.70, 19 , 3 ,552.2922
Set Internal Change=Bald Eagle      ,Loc Hav         ,24843.25, 19 , 3 ,551.4984
Set Internal Change=Bald Eagle      ,Loc Hav         ,24417.73, 19 , 3 ,551.2458
Set Internal Change=Bald Eagle      ,Loc Hav         ,23872.06, 19 , 3 ,550.3901
Set Internal Change=Bald Eagle      ,Loc Hav         ,23783.65, 19 , 3 ,550.3581
Set Internal Change=Bald Eagle      ,Loc Hav         ,23384.79, 19 , 3 ,550.2433
Set Internal Change=Bald Eagle      ,Loc Hav         ,22982.97, 19 , 3 ,550.1008
Set Internal Change=Bald Eagle      ,Loc Hav         ,22386.15, 19 , 3 ,549.7363
Set Internal Change=Bald Eagle      ,Loc Hav         ,21283.34, 19 , 3 ,549.218
Set Internal Change=Bald Eagle      ,Loc Hav         ,21199.93, 19 , 3 ,549.17
Set Internal Change=Bald Eagle      ,Loc Hav         ,20127.30, 19 , 3 ,548.655
Set Internal Change=Bald Eagle      ,Loc Hav         ,19036.24, 19 , 3 ,547.6036
Set Internal Change=Bald Eagle      ,Loc Hav         ,18200.10, 19 , 3 ,547.1831
Set Internal Change=Bald Eagle      ,Loc Hav         ,17549.23, 19 , 3 ,547.0572
Set Internal Change=Bald Eagle      ,Loc Hav         ,16787.45, 19 , 3 ,546.8553
Set Internal Change=Bald Eagle      ,Loc Hav         ,15407.88, 19 , 3 ,546.2723
Set Internal Change=Bald Eagle      ,Loc Hav         ,14814.34, 19 , 3 ,545.8101
Set Internal Change=Bald Eagle      ,Loc Hav         ,13326.74, 19 , 3 ,545.2358
Set Internal Change=Bald Eagle      ,Loc Hav         ,12035.22, 19 , 3 ,544.8991
Set Internal Change=Bald Eagle      ,Loc Hav         ,11865.80, 19 , 3 ,544.8576
Set Internal Change=Bald Eagle      ,Loc Hav         ,11116.44, 19 , 3 ,544.5386
Set Internal Change=Bald Eagle      ,Loc Hav         ,10995.73, 19 , 3 ,544.493
Set Internal Change=Bald Eagle      ,Loc Hav         ,10221.14, 19 , 3 ,544.1406
Set Internal Change=Bald Eagle      ,Loc Hav         ,9258.941, 19 , 3 ,543.8405
Set Internal Change=Bald Eagle      ,Loc Hav         ,8541.462, 19 , 3 ,543.7215
Set Internal Change=Bald Eagle      ,Loc Hav         ,7936.130, 19 , 3 ,543.5922
Set Internal Change=Bald Eagle      ,Loc Hav         ,6940.066, 19 , 3 ,543.2958
Set Internal Change=Bald Eagle      ,Loc Hav         ,6267.489, 19 , 3 ,543.1386
Set Internal Change=Bald Eagle      ,Loc Hav         ,5523.234, 19 , 3 ,542.9716
Set Internal Change=Bald Eagle      ,Loc Hav         ,4293.710, 19 , 3 ,542.6807
Set Internal Change=Bald Eagle      ,Loc Hav         ,3047.378, 19 , 3 ,542.4032
Set Internal Change=Bald Eagle      ,Loc Hav         ,2731.142, 19 , 3 ,542.2909
Set Internal Change=Bald Eagle      ,Loc Hav         ,2501.017, 19 , 3 ,542.2943
Set Internal Change=Bald Eagle      ,Loc Hav    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